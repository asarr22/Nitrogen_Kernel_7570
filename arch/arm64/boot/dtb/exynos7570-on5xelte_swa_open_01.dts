# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts"
# 1 "<built-in>"
# 1 "<command-line>"
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts"
# 12 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts"
/dts-v1/;
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rmem.dtsi" 1
# 12 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rmem.dtsi"
/memreserve/ 0x7E700000 0x100000;

/ {
 reserved-memory {
  #address-cells = <2>;
  #size-cells = <1>;
  ranges;

  tima_mem: tima_region@0x52800000 {
   compatible = "removed-dma-pool";
   reg = <0x0 0x52800000 0x200000>;
  };

  camera {
   compatible = "exynos8890-ion,camera";
   reg = <0x0 0x710EF000 0x1000>;
   id = <10>;
  };

  video_nfw {
   compatible = "exynos7570-mfc,vnfw";
   reg = <0x0 0x710F0000 0x110000>;
   fixed_upper_base = <0xffffff80>;
   fixed_lower_base = <0x40000000>;
  };

  video_stream {
   compatible = "exynos8890-ion,vstream";
   secure;
   reg = <0x0 0x72200000 0x1200000>;
   id = <3>;
   compat-id = <25 31>;
  };

  modem_if {
   compatible = "exynos,modem_if";
   reg = <0 0x73400000 0x5C00000>;
  };

  wifibt_if {
   compatible = "exynos,wifibt_if";
   reg = <0 0x79000000 0x400000>;
  };

  crypto {
   compatible = "exynos8890-ion,crypto";
   reusable;
   reg = <0x0 0x79400000 0x800000>;
   id = <1>;
  };

  video_frame {
   compatible = "exynos8890-ion,vframe";
   secure;
   reusable;
   ion,bulk_reclaim;
   reg = <0x0 0x79C00000 0x3800000>;
   id = <5>;
   compat-id = <26 29>;
  };

  video_scaler {
   compatible = "exynos8890-ion,vscaler";
   secure;
   reusable;
   reg = <0x0 0x71200000 0x1000000>;
   id = <6>;
   compat-id = <28>;
  };

  gnss_if {
   compatible = "exynos,gnss_if";
   reg = <0 0x7E100000 0x200000>;
  };

 };

 ect {
  parameter_address = <0x7E0FA000>;
  parameter_size = <0x6000>;
 };
};
# 14 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xe_common.dtsi" 1
# 12 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xe_common.dtsi"
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi" 1
# 16 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi"
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/include/dt-bindings/clock/exynos7570.h" 1
# 17 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/include/dt-bindings/sysmmu/sysmmu.h" 1
# 18 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/include/dt-bindings/thermal/thermal.h" 1
# 19 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-pinctrl.dtsi" 1
# 15 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-pinctrl.dtsi"
/ {

 pinctrl@139F0000 {
  etc0: etc0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  etc1: etc1 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpa0: gpa0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
   interrupt-parent = <&gic>;
   interrupts = <0 0 0>, <0 1 0>, <0 2 0>, <0 3 0>,
         <0 4 0>, <0 5 0>, <0 6 0>, <0 7 0>;
  };

  dwmmc2_cd_ext_irq: dwmmc2_cd_ext_irq {
   samsung,pins = "gpa0-1";
   samsung,pin-function = <0xf>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <4>;
  };

  gpa1: gpa1 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <3>;
   interrupt-parent = <&gic>;
   interrupts = <0 8 0>, <0 9 0>, <0 10 0>, <0 11 0>,
         <0 12 0>, <0 13 0>, <0 14 0>, <0 15 0>;
  };

  gpa2: gpa2 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpq0: gpq0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };


  uart2_bus: uart2-bus {
   samsung,pins = "gpa1-6", "gpa1-5";
   samsung,pin-function = <3>;
   samsung,pin-pud = <0>;
  };

  uart2_sleep: uart2-sleep {
          samsung,pins = "gpa1-6";
          samsung,pin-function = <0>;
          samsung,pin-pud = <1>;
  };


  i2c6_bus: i2c6-bus {
   samsung,pins = "gpa1-6", "gpa1-5";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  cp_gpio: cp_gpio {
   samsung,pins = "gpa1-7", "gpa2-1";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_on5: cp_gpio_on5 {
   samsung,pins = "gpa1-7";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_j3pop_old: cp_gpio_j3pop_old {
   samsung,pins = "gpa1-3";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_j3pop: cp_gpio_j3pop {
   samsung,pins = "gpa2-3";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_x4: cp_gpio_x4 {
   samsung,pins = "gpa1-7", "gpa2-0", "gpa2-1", "gpa2-4";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_w: cp_gpio_w {
   samsung,pins = "gpa2-5", "gpa2-6";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_iot: cp_gpio_iot {
   samsung,pins = "gpa1-3", "gpa2-0", "gpa2-2", "gpa2-7";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_j3y17_rev0: cp_gpio_j3y17_rev0 {
   samsung,pins = "gpa1-7", "gpa2-6", "gpa2-5";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_j3y17_rev1: cp_gpio_j3y17_rev1 {
   samsung,pins = "gpa1-7", "gpa2-6";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_j4lte: cp_gpio_j4lte {
   samsung,pins = "gpa2-6";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_j2corelte: cp_gpio_j2corelte {
   samsung,pins = "gpa1-7" , "gpa2-6" , "gpa2-7";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_tabes_vzw: cp_gpio_tabes_vzw {
   samsung,pins = "gpa2-0", "gpa2-1", "gpa2-2";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_tabes_vzw_rev1: cp_gpio_tabes_vzw_rev1 {
   samsung,pins = "gpa1-7", "gpa2-0", "gpa2-1", "gpa2-2";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  cp_gpio_j3neoelte: cp_gpio_j3neoelte {
   samsung,pins = "gpa1-7", "gpa2-2", "gpa2-3", "gpa2-4", "gpa2-5", "gpa2-6", "gpa2-7";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };

  sim_gpio_default_on5: sim_gpio_default_on5 {
   samsung,pins = "gpa2-4";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
  };

  sim0_gpio_on5: sim0_gpio_on5 {
   samsung,pins = "gpa2-4";
   samsung,pin-function = <15>;
   samsung,pin-pud = <0>;
  };

  sim1_gpio_on5: sim1_gpio_on5 {
   samsung,pins = "gpa1-4";
   samsung,pin-function = <15>;
   samsung,pin-pud = <0>;
  };

  fimc_is_flash: fimc-is-flash {
   samsung,pins = "gpa0-0";
   samsung,pin-function = <1>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };


  uart3_bus_single: uart3-bus-single {
   samsung,pins = "gpa2-0", "gpa1-7", "gpa2-1", "gpa2-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
  };


  uart3_bus_dual: uart3-bus-dual {
   samsung,pins = "gpa2-0", "gpa1-7";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
  };


  uart4_bus_single: uart4-bus-single {
   samsung,pins = "gpa2-5", "gpa2-4", "gpa2-6", "gpa2-7";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
  };


  uart4_bus_dual: uart4-bus-dual {
   samsung,pins = "gpa2-5", "gpa2-4";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
  };


  hs_i2c5_bus: hs-i2c5-bus {
   samsung,pins = "gpa2-0", "gpa1-7";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  hs_i2c6_bus: hs-i2c6-bus {
   samsung,pins = "gpa2-2", "gpa2-1";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  hs_i2c7_bus: hs-i2c7-bus {
   samsung,pins = "gpa2-5", "gpa2-4";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  hs_i2c8_bus: hs-i2c8-bus {
   samsung,pins = "gpa2-7", "gpa2-6";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  spi2_bus: spi2-bus {
   samsung,pins = "gpa2-0", "gpa1-7", "gpa2-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  spi2_cs_0: spi2-cs-0 {
   samsung,pins = "gpa2-1";
   samsung,pin-function = <1>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  spi3_bus: spi3-bus {
   samsung,pins = "gpa2-5", "gpa2-4", "gpa2-7";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  spi3_cs_0: spi3-cs-0 {
   samsung,pins = "gpa2-6";
   samsung,pin-function = <1>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

               fimc_is_mclk1_in: fimc_is_mclk1_in {
                       samsung,pins = "gpa2-3";
                       samsung,pin-function = <0>;
                       samsung,pin-pud = <0>;
                       samsung,pin-drv = <0>;
               };

               fimc_is_mclk1_out: fimc_is_mclk1_out {
                       samsung,pins = "gpa2-3";
                       samsung,pin-function = <1>;
                       samsung,pin-pud = <1>;
                       samsung,pin-drv = <2>;
               };

               fimc_is_mclk1_fn: fimc_is_mclk1_fn {
                       samsung,pins = "gpa2-3";
                       samsung,pin-function = <2>;
                       samsung,pin-pud = <0>;
                       samsung,pin-drv = <1>;
               };
 };


 pinctrl@139E0000 {
  gpc7: gpc7 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };


  spi0_bus: spi0-bus {
   samsung,pins = "gpc7-3", "gpc7-2", "gpc7-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  spi0_cs_0: spi0-cs-0 {
   samsung,pins = "gpc7-1";
   samsung,pin-function = <1>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  spi0_cs_1: spi0-cs-1 {
   samsung,pins = "gpc7-4";
   samsung,pin-function = <1>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };
 };


 pinctrl@148C0000 {
  gpz1: gpz1 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  i2s_pmic_bus: i2s-pmic-bus {
   samsung,pins = "gpz1-0", "gpz1-1", "gpz1-2", "gpz1-3";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };

  i2s_pmic_bus_idle: i2s-pmic-bus-idle {
   samsung,pins = "gpz1-0", "gpz1-1", "gpz1-2", "gpz1-3";
   samsung,pin-function = <0>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };

  i2s_codec_clk: i2s-codec-clk {
   samsung,pins = "gpz1-4";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };
  i2s_amp_bus: i2s-amp-bus {
   samsung,pins = "gpz1-5";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  i2s_amp_bus_idle: i2s-amp-bus-idle {
   samsung,pins = "gpz1-5";
   samsung,pin-function = <0>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };
  fm_speedy_bus: fm-speedy-bus {
   samsung,pins = "gpz1-6";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  fm_speedy_bus_idle: fm-speedy-bus-idle {
   samsung,pins = "gpz1-6";
   samsung,pin-function = <0>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };
 };


 pinctrl@13750000 {
  gpr0: gpr0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpr1: gpr1 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpr4: gpr4 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  sd0_clk: sd0-clk {
   samsung,pins = "gpr0-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <2>;
  };

  sd0_cmd: sd0-cmd {
   samsung,pins = "gpr0-1";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  sd0_rdqs: sd0-rdqs {
   samsung,pins = "gpr0-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <2>;
  };

  sd0_clk_fast_slew_rate_1x: sd0-clk_fast_slew_rate_1x {
   samsung,pins = "gpr0-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };

  sd0_clk_fast_slew_rate_2x: sd0-clk_fast_slew_rate_2x {
   samsung,pins = "gpr0-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <1>;
  };

  sd0_clk_fast_slew_rate_3x: sd0-clk_fast_slew_rate_3x {
   samsung,pins = "gpr0-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <2>;
  };

  sd0_clk_fast_slew_rate_4x: sd0-clk_fast_slew_rate_4x {
   samsung,pins = "gpr0-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <3>;
  };

  sd0_bus1: sd0-bus-width1 {
   samsung,pins = "gpr1-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  sd0_bus4: sd0-bus-width4 {
   samsung,pins = "gpr1-1", "gpr1-2", "gpr1-3";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  sd0_bus8: sd0-bus-width8 {
   samsung,pins = "gpr1-4", "gpr1-5", "gpr1-6", "gpr1-7";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  sd2_clk: sd2-clk {
   samsung,pins = "gpr4-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <2>;
  };

  sd2_cmd: sd2-cmd {
   samsung,pins = "gpr4-1";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  sd2_bus1: sd2-bus-width1 {
   samsung,pins = "gpr4-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  sd2_bus4: sd2-bus-width4 {
   samsung,pins = "gpr4-3", "gpr4-4", "gpr4-5";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <2>;
  };

  sd2_clk_fast_slew_rate_1x: sd2-clk_fast_slew_rate_1x {
   samsung,pins = "gpr4-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };

  sd2_clk_fast_slew_rate_2x: sd2-clk_fast_slew_rate_2x {
   samsung,pins = "gpr4-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <1>;
  };

  sd2_clk_fast_slew_rate_3x: sd2-clk_fast_slew_rate_3x {
   samsung,pins = "gpr4-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <2>;
  };

  sd2_clk_fast_slew_rate_4x: sd2-clk_fast_slew_rate_4x {
   samsung,pins = "gpr4-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <3>;
  };
 };


 pinctrl@10530000 {
  gpm0: gpm0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  speedy_bus: speedy-bus {
   samsung,pins = "gpm0-0";
   samsung,pin-function = <2>;
   samsung,pin-drv = <0>;
   samsung,pin-con-pdn = <3>;
  };
 };


 pinctrl@139C0000 {
  gpc2: gpc2 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };


  i2c2_bus: i2c2-bus {
   samsung,pins = "gpc2-1", "gpc2-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  gpio_nfc: gpio-nfc {
   samsung,pins = "gpc2-2";
   samsung,pin-function = <0x1>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
   samsung,pin-con-pdn = <3>;
   samsung,pin-val = <1>;
  };

  nfc_pd: nfc_pd {
   samsung,pins = "gpc2-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  nfc_clk_req: nfc_clk_req {
   samsung,pins = "gpc2-3";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };

 };


 pinctrl@139B0000 {
  gpc0: gpc0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpc1: gpc1 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpc4: gpc4 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpd1: gpd1 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpe0: gpe0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpf0: gpf0 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpf1: gpf1 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpf3: gpf3 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };


  decon_te_on: decon_te_on {
   samsung,pins = "gpe0-2";
   samsung,pin-function = <2>;
  };

  decon_te_off: decon_te_off {
   samsung,pins = "gpe0-2";
   samsung,pin-function = <0>;
  };


  uart1_bus: uart1-bus {
   samsung,pins = "gpc4-3", "gpc4-2";
   samsung,pin-function = <4>;
   samsung,pin-pud = <0>;
  };


  i2c1_bus: i2c1-bus {
   samsung,pins = "gpc1-3", "gpc1-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  i2c4_bus: i2c4-bus {
   samsung,pins = "gpc4-1", "gpc4-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  i2c5_bus: i2c5-bus {
   samsung,pins = "gpc4-3", "gpc4-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  hs_i2c0_bus: hs-i2c0-bus {
   samsung,pins = "gpf3-0", "gpf3-1";
   samsung,pin-function = <3>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
   samsung,pin-con-pdn = <3>;
  };


  hs_i2c1_bus: hs-i2c1-bus {
   samsung,pins = "gpf3-2", "gpf3-3";
   samsung,pin-function = <3>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
   samsung,pin-con-pdn = <3>;
  };


  hs_i2c2_bus: hs-i2c2-bus {
   samsung,pins = "gpf0-1", "gpf0-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
   samsung,pin-con-pdn = <3>;
  };


  hs_i2c3_bus: hs-i2c3-bus {
   samsung,pins = "gpf0-3", "gpf0-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
   samsung,pin-con-pdn = <3>;
  };


  hs_i2c4_bus: hs-i2c4-bus {
   samsung,pins = "gpf1-1", "gpf1-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
   samsung,pin-con-pdn = <3>;
  };


  spi1_bus: spi1-bus {
   samsung,pins = "gpf3-3", "gpf3-2", "gpf3-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  spi1_cs_0: spi1-cs-0 {
   samsung,pins = "gpf3-1";
   samsung,pin-function = <1>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  spi1_cs_1: spi1-cs-1 {
   samsung,pins = "gpd1-0";
   samsung,pin-function = <1>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };


  pwm_tout0: pwm-tout0 {
   samsung,pins = "gpc0-1";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };

  pwm_tout1: pwm-tout1 {
   samsung,pins = "gpc0-2";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };

  fimc_is_mclk0_in: fimc_is_mclk0_in {
   samsung,pins = "gpe0-0";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };

  fimc_is_mclk0_out: fimc_is_mclk0_out {
   samsung,pins = "gpe0-0";
   samsung,pin-function = <1>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <2>;
  };

  fimc_is_mclk0_fn: fimc_is_mclk0_fn {
   samsung,pins = "gpe0-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <1>;
  };

  nfc_firm: nfc_firm {
   samsung,pins = "gpd1-0";
   samsung,pin-function = <1>;
   samsung,pin-pud = <1>;
   samsung,pin-val = <0>;
  };

  nfc_pvdd_en: nfc_pvdd_en {
   samsung,pins = "gpf1-0";
   samsung,pin-function = <1>;
   samsung,pin-pud = <3>;
   samsung,pin-val = <0>;
  };
  ese_pvdd_en: ese_pvdd_en {
   samsung,pins = "gpf1-1";
   samsung,pin-function = <1>;
   samsung,pin-pud = <1>;
   samsung,pin-val = <0>;
  };
 };


 pinctrl@139D0000 {
  gpc3: gpc3 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpd2: gpd2 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };


  i2c3_bus: i2c3-bus {
   samsung,pins = "gpc3-1", "gpc3-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };
 };
};
# 20 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-itm.dtsi" 1
# 16 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-itm.dtsi"
/ {
 ITM@0 {
  compatible = "samsung,exynos-itm";
 };
};
# 21 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-pm-domains.dtsi" 1
# 15 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-pm-domains.dtsi"
/ {
 pd_dispaud: pd-dispaud@11C84020 {
  compatible = "samsung,exynos-pd";
  reg = <0x0 0x11C84020 0x20>;
  cal_id = <0xB138000D>;
  status = "okay";
  check-cp-status = "true";

  spd_aud: spd-aud@11C84020 {
   compatible = "samsung,exynos-spd";
  };

  spd_disp: spd-disp@11C84020 {
   compatible = "samsung,exynos-spd";
  };

  spd_fm: spd-fm@11C84020 {
   compatible = "samsung,exynos-spd";
  };
 };

 pd_isp: pd-isp@11C84040 {
  compatible = "samsung,exynos-pd";
  reg = <0x0 0x11C84040 0x20>;
  parent = <&pd_mfcmscl>;
  cal_id = <0xB1380003>;
  devfreq-sync-voltage = <3>;
  status = "okay";
 };

 pd_mfcmscl: pd-mfcmscl@11C84060 {
  compatible = "samsung,exynos-pd";
  reg = <0x0 0x11C84060 0x20>;
  cal_id = <0xB1380008>;
  status = "okay";
 };

 pd_g3d: pd-g3d@11C84000 {
  compatible = "samsung,exynos-pd";
  reg = <0x0 0x11C84000 0x20>;
  cal_id = <0xB1380000>;
  status = "okay";
 };

 dbgdev-pd-dispaud {
  compatible = "samsung,exynos-pd-dbg";
  samsung,power-domain = <&pd_dispaud>;
 };

 dbgdev-pd-isp {
  compatible = "samsung,exynos-pd-dbg";
  samsung,power-domain = <&pd_isp>;
 };

 dbgdev-pd-mfcmscl {
  compatible = "samsung,exynos-pd-dbg";
  samsung,power-domain = <&pd_mfcmscl>;
 };

 dbgdev-pd-g3d {
  compatible = "samsung,exynos-pd-dbg";
  samsung,power-domain = <&pd_g3d>;
 };
};
# 22 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi" 2

/ {
 compatible = "samsung,armv8", "samsung,exynos7570";
 interrupt-parent = <&gic>;
 #address-cells = <2>;
 #size-cells = <1>;

 arm-pmu {
  compatible = "arm,armv8-pmuv3";
  interrupts = <0 50 4>,
        <0 51 4>,
        <0 52 4>,
        <0 53 4>;
 };

 aliases {
  pinctrl0 = &pinctrl_0;
  pinctrl1 = &pinctrl_1;
  pinctrl2 = &pinctrl_2;
  pinctrl3 = &pinctrl_3;
  pinctrl4 = &pinctrl_4;
  pinctrl5 = &pinctrl_5;
  pinctrl6 = &pinctrl_6;
  pinctrl7 = &pinctrl_7;
  uart1 = &serial_1;
  uart2 = &serial_2;
  uart3 = &serial_3;
  uart4 = &serial_4;
  hsi2c0 = &hsi2c_0;
  hsi2c1 = &hsi2c_1;
  hsi2c2 = &hsi2c_2;
  hsi2c3 = &hsi2c_3;
  hsi2c4 = &hsi2c_4;
  hsi2c5 = &hsi2c_5;
  hsi2c6 = &hsi2c_6;
  hsi2c7 = &hsi2c_7;
  hsi2c8 = &hsi2c_8;
  spi0 = &spi_0;
  spi1 = &spi_1;
  spi2 = &spi_2;
  spi3 = &spi_3;
  mshc0 = &dwmmc_0;
  mshc2 = &dwmmc_2;
  decon0 = &decon_0;
  dsim0 = &dsim_0;
  tmuctrl0 = &tmuctrl_0;
  tmuctrl1 = &tmuctrl_1;
  scaler0 = &scaler_0;
  mfc0 = &mfc_0;
 };

 chipid@10100000 {
  compatible = "samsung,exynos4210-chipid";
  reg = <0x0 0x10100000 0x100>;
 };

 reboot {
  compatible = "exynos,reboot";
  pmu_base = <0x11C80000>;
 };

 cpus {
  #address-cells = <2>;
  #size-cells = <0>;

  cpu@0 {
   device_type = "cpu";
   compatible = "arm,cortex-a53", "arm,armv8";
   reg = <0x0 0x0>;
   enable-method = "psci";
   cpu-idle-states = <&CPU_SLEEP>;
  };
  cpu@1 {
   device_type = "cpu";
   compatible = "arm,cortex-a53", "arm,armv8";
   reg = <0x0 0x1>;
   enable-method = "psci";
   cpu-idle-states = <&CPU_SLEEP>;
  };
  cpu@2 {
   device_type = "cpu";
   compatible = "arm,cortex-a53", "arm,armv8";
   reg = <0x0 0x2>;
   enable-method = "psci";
   cpu-idle-states = <&CPU_SLEEP>;
  };
  cpu@3 {
   device_type = "cpu";
   compatible = "arm,cortex-a53", "arm,armv8";
   reg = <0x0 0x3>;
   enable-method = "psci";
   cpu-idle-states = <&CPU_SLEEP>;
  };
  idle-states {
   entry-method = "arm,psci";

   CPU_SLEEP: cpu-sleep {
    desc = "cpu sleep";
    compatible = "exynos,idle-state";
    arm,psci-suspend-param = <0x0010000>;
    entry-latency-us = <35>;
    exit-latency-us = <90>;
    min-residency-us = <750>;
    status = "okay";
   };
  };
 };

 psci {
                compatible = "arm,psci";
                method = "smc";
                cpu_suspend = <0xC4000001>;
                cpu_off = <0x84000002>;
                cpu_on = <0xC4000003>;
        };

 cpufreq {
  compatible = "samsung,exynos-sc-cpufreq";

                cl0_idx_num = <17>;
                cl0_max_support_idx = <5>;
                cl0_min_support_idx = <14>;
                cl0_boot_max_qos = <1378000>;
                cl0_boot_min_qos = <1378000>;
                cl0_boot_lock_time = <40000000>;
                cl0_en_ema = <0>;
                cl0_regulator = "BUCK1";

                cl0_dvfs_domain_name = "dvfs_cpucl0";
 };

 gic:interrupt-controller@104E1000 {
  compatible = "arm,cortex-a15-gic", "arm,cortex-a9-gic";
  #interrupt-cells = <3>;
  #address-cells = <0>;
  interrupt-controller;
  reg = <0x0 0x104E1000 0x1000>,
   <0x0 0x104E2000 0x1000>,
   <0x0 0x104E4000 0x2000>,
   <0x0 0x104E6000 0x2000>;
  interrupts = <1 9 0xf04>;
 };

 timer {
         compatible = "arm,armv8-timer";
         interrupts = <1 13 0xff01>,
                      <1 14 0xff01>,
                      <1 11 0xff01>,
                      <1 10 0xff01>;
         clock-frequency = <26000000>;
  use-clocksource-only;
 };

 clock: clock-controller@0x10460000 {
  compatible = "samsung,exynos7570-clock";
  reg = <0x0 0x10460000 0x1000>;
  #clock-cells = <1>;
 };

 pmu_system_controller: system-controller@11C80000 {
  compatible = "samsung,exynos7570-pmu", "syscon";
  reg = <0x0 0x11C80000 0x10000>;
 };

 exynos-pmu {
  compatible = "samsung,exynos-pmu";
  samsung,syscon-phandle = <&pmu_system_controller>;
 };

 mct@101B0000 {
  compatible = "samsung,exynos4210-mct";
  reg = <0x0 0x101B0000 0x800>;
  interrupt-controller;
  #interrupt-cells = <1>;
  interrupt-parent = <&mct_map>;
  interrupts = <0>, <1>, <2>, <3>,
    <4>, <5>, <6>, <7>,
    <8>, <9>, <10>, <11>;
  clocks = <&clock 1>, <&clock 370>;
  clock-names = "fin_pll", "mct";
  use-clockevent-only;

  mct_map: mct-map {
   #interrupt-cells = <1>;
   #address-cells = <0>;
   #size-cells = <0>;
   interrupt-map = <0 &gic 0 102 0>,
     <1 &gic 0 103 0>,
     <2 &gic 0 104 0>,
     <3 &gic 0 105 0>,
     <4 &gic 0 106 0>,
     <5 &gic 0 107 0>,
     <6 &gic 0 108 0>,
     <7 &gic 0 109 0>,
     <8 &gic 0 110 0>,
     <9 &gic 0 111 0>,
     <10 &gic 0 112 0>,
     <11 &gic 0 113 0>;
  };
 };

 devfreq_0: devfreq_mif@17000010 {
  compatible = "samsung,exynos-devfreq";
  reg = <0x0 0x17000010 0x0>;
  clocks = <&clock 1000>, <&clock 1001>;
  clock-names = "dvfs_mif", "dvfs_mif_sw";
  devfreq_type = "mif";
  devfreq_domain_name = "dvfs_mif";


  use_delay_time = "true";
  delay_time_list = "20";


  freq_info = <666000 415000 415000 415000 666000 415000>;


  boot_qos_timeout = <40>;

  use_get_dev = "false";
  polling_ms = <0>;


  gov_name = "interactive";


  use_reg = "true";
  use_pd_off = "false";
  reg_name = "BUCK1";

  volt_info = <25000 1250000 0 1300000>;

  use_tmu = "true";
  use_cl_dvfs = "false";
  use_sw_clk = "true";
 };

 devfreq_1: devfreq_int@17000020 {
  compatible = "samsung,exynos-devfreq";
  reg = <0x0 0x17000020 0x0>;
  clocks = <&clock 1002>;
  clock-names = "dvfs_int";
  devfreq_type = "int";
  devfreq_domain_name = "dvfs_int";


  use_delay_time = "false";


  freq_info = <467000 415000 467000 415000 467000 415000>;


  boot_qos_timeout = <40>;


  use_get_dev = "false";
  polling_ms = <0>;


  gov_name = "interactive";


  use_reg = "true";
  use_pd_off = "false";
  reg_name = "BUCK1";

  volt_info = <25000 1250000 0 1300000>;

  use_tmu = "true";
  use_cl_dvfs = "false";
  use_sw_clk = "false";
 };

 devfreq_2: devfreq_disp@17000030 {
  compatible = "samsung,exynos-devfreq";
  reg = <0x0 0x17000030 0x0>;
  clocks = <&clock 1004>;
  clock-names = "dvfs_disp";
  devfreq_type = "disp";
  devfreq_domain_name = "dvfs_disp";


  use_delay_time = "false";


  freq_info = <208000 208000 208000 208000 208000 208000>;


  boot_qos_timeout = <40>;


  use_get_dev = "false";
  polling_ms = <0>;


  gov_name = "interactive";


  use_reg = "true";
  use_pd_off = "false";
  reg_name = "BUCK1";

  volt_info = <25000 1250000 0 1300000>;

  use_tmu = "true";
  use_cl_dvfs = "false";
  use_sw_clk = "false";
 };

 devfreq_3: devfreq_cam@17000040 {
  compatible = "samsung,exynos-devfreq";
  reg = <0x0 0x17000040 0x0>;
  clocks = <&clock 1003>;
  clock-names = "dvfs_cam";
  devfreq_type = "cam";
  devfreq_domain_name = "dvfs_cam";


  use_delay_time = "false";


  freq_info = <444000 444000 444000 444000 554000 444000>;


  boot_qos_timeout = <0>;


  use_get_dev = "false";
  polling_ms = <0>;


  gov_name = "interactive";


  use_reg = "true";
  use_pd_off = "true";
  reg_name = "BUCK1";

  volt_info = <25000 1250000 0 1300000>;

  use_tmu = "true";
  use_cl_dvfs = "false";
  use_sw_clk = "false";
 };

 pinctrl_0: pinctrl@139F0000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x139F0000 0x1000>;
  interrupts = <0 0 0>, <0 1 0>, <0 2 0>, <0 3 0>,
    <0 4 0>, <0 5 0>, <0 6 0>, <0 7 0>,
    <0 8 0>, <0 9 0>, <0 10 0>, <0 11 0>,
    <0 12 0>, <0 13 0>, <0 14 0>, <0 15 0>;
  wakeup-interrupt-controller {
   compatible = "samsung,exynos4210-wakeup-eint";
   interrupt-parent = <&gic>;
   interrupts = <0 16 0>;
   samsung,eint-flt-conf;
  };
 };


 pinctrl_1: pinctrl@148C0000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x148C0000 0x1000>;
  interrupts = <0 68 0>;
 };


 pinctrl_2: pinctrl@139E0000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x139E0000 0x1000>;
  interrupts = <0 441 0>;
 };


 pinctrl_3: pinctrl@13750000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x13750000 0x1000>;
  interrupts = <0 250 0>;
 };


 pinctrl_4: pinctrl@10530000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x10530000 0x1000>;
  interrupts = <0 392 0>;
 };


 pinctrl_5: pinctrl@139C0000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x139C0000 0x1000>;
  interrupts = <0 439 0>;
 };


 pinctrl_6: pinctrl@139B0000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x139B0000 0x1000>;
  interrupts = <0 438 0>;
 };


 pinctrl_7: pinctrl@139D0000 {
  compatible = "samsung,exynos7570-pinctrl";
  reg = <0x0 0x139D0000 0x1000>;
  interrupts = <0 440 0>;
 };


 usi_0: usi@101D2000 {
  compatible = "samsung,exynos-usi";
  reg = <0x0 0x101D2000 0x100>;


  status = "disabled";
 };


 usi_1: usi@101D3000 {
  compatible = "samsung,exynos-usi";
  reg = <0x0 0x101D3000 0x100>;


  status = "disabled";
 };


 serial_1: uart@13800000 {
  compatible = "samsung,exynos-uart";
  samsung,separate-uart-clk;
  reg = <0x0 0x13800000 0x100>;
  samsung,fifo-size = <16>;
  interrupts = <0 421 0>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart1_bus>;
  clocks = <&clock 361>, <&clock 21>, <&clock 21>;
  clock-names = "gate_pclk1", "gate_uart1", "sclk_uart1";
  status = "disabled";
 };


 serial_2: uart@13820000 {
  compatible = "samsung,exynos-uart";
  samsung,separate-uart-clk;
  samsung,alive-io;
  reg = <0x0 0x13820000 0x100>;
  samsung,fifo-size = <256>;
  interrupts = <0 423 0>;
  pinctrl-names = "default", "uart_sleep";
  pinctrl-0 = <&uart2_bus>;
  pinctrl-1 = <&uart2_sleep>;
  clocks = <&clock 360>, <&clock 20>, <&clock 20>;
  clock-names = "gate_pclk2", "gate_uart2", "sclk_uart2";
  status = "disabled";
 };


 uart_sel {
  compatible = "samsung,exynos-uart-sel";

  int_ap2cp_uart_noti = <15>;
  mbx_ap2cp_united_status = <2>;
  sbi_uart_noti_mask = <0x1>;
  sbi_uart_noti_pos = <16>;
 };


 usim_det {
  compatible = "samsung,exynos-usim-detect";

  mbx_ap2cp_united_status = <2>;

  mif,int_usim0_det_level = <4>;
  mif,int_usim1_det_level = <5>;

  sbi_usim0_det_mask = <1>;
  sbi_usim0_det_pos = <17>;
  sbi_usim1_det_mask = <1>;
  sbi_usim1_det_pos = <18>;
 };


 serial_3: uart@13910000 {
  compatible = "samsung,exynos-uart";
  samsung,separate-uart-clk;
  reg = <0x0 0x13910000 0x100>;

  samsung,fifo-size = <32>;
  interrupts = <0 461 0>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart3_bus_single>;
  clocks = <&clock 351>, <&clock 40>, <&clock 40>;
  clock-names = "gate_pclk3", "gate_uart3", "sclk_uart3";
  status = "disabled";
 };


 serial_4: uart@13930000 {
  compatible = "samsung,exynos-uart";
  samsung,separate-uart-clk;
  reg = <0x0 0x13930000 0x100>;

  samsung,fifo-size = <32>;
  interrupts = <0 465 0>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart4_bus_single>;
  clocks = <&clock 352>, <&clock 41>, <&clock 41>;
  clock-names = "gate_pclk4", "gate_uart4", "sclk_uart4";
  status = "disabled";
 };


 i2c_1: i2c@13880000 {
  compatible = "samsung,s3c2440-i2c";
  reg = <0x0 0x13880000 0x100>;
  interrupts = <0 429 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  samsung,i2c-clk-logging;
  pinctrl-names = "default";
  pinctrl-0 = <&i2c1_bus>;
  clocks = <&clock 312>, <&clock 312>;
  clock-names = "rate_i2c", "gate_i2c";
  status = "disabled";
 };


 i2c_2: i2c@13890000 {
  compatible = "samsung,s3c2440-i2c";
  reg = <0x0 0x13890000 0x100>;
  interrupts = <0 430 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&i2c2_bus>;
  clocks = <&clock 311>, <&clock 311>;
  clock-names = "rate_i2c", "gate_i2c";
  status = "disabled";
 };


 i2c_3: i2c@13840000 {
  compatible = "samsung,s3c2440-i2c";
  reg = <0x0 0x13840000 0x100>;
  interrupts = <0 425 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&i2c3_bus>;
  clocks = <&clock 302>, <&clock 302>;
  clock-names = "rate_i2c", "gate_i2c";
  status = "disabled";
 };


 i2c_4: i2c@13830000 {
  compatible = "samsung,s3c2440-i2c";
  reg = <0x0 0x13830000 0x100>;
  interrupts = <0 424 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&i2c4_bus>;
  clocks = <&clock 310>, <&clock 310>;
  clock-names = "rate_i2c", "gate_i2c";
  status = "disabled";
 };


 i2c_5: i2c@138D0000 {
  compatible = "samsung,s3c2440-i2c";
  reg = <0x0 0x138D0000 0x100>;
  interrupts = <0 453 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&i2c5_bus>;
  clocks = <&clock 300>, <&clock 300>;
  clock-names = "rate_i2c", "gate_i2c";
  status = "disabled";
 };


 i2c_6: i2c@138E0000 {
  compatible = "samsung,s3c2440-i2c";
  reg = <0x0 0x138E0000 0x100>;
  interrupts = <0 454 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&i2c6_bus>;
  clocks = <&clock 301>, <&clock 301>;
  clock-names = "rate_i2c", "gate_i2c";
  status = "disabled";
 };


 hsi2c_0: hsi2c@13950000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x13950000 0x1000>;
  interrupts = <0 457 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c0_bus>;
  clocks = <&clock 332>, <&clock 332>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpf3 1 0x1>;
  gpio_scl= <&gpf3 0 0x1>;
  status = "disabled";
 };


 hsi2c_1: hsi2c@13960000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x13960000 0x1000>;
  interrupts = <0 458 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c1_bus>;
  clocks = <&clock 333>, <&clock 333>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpf3 3 0x1>;
  gpio_scl= <&gpf3 2 0x1>;
  status = "disabled";
 };


 hsi2c_2: hsi2c@138A0000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x138A0000 0x1000>;
  interrupts = <0 449 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c2_bus>;
  clocks = <&clock 321>, <&clock 321>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpf0 0 0x1>;
  gpio_scl= <&gpf0 1 0x1>;
  status = "disabled";
 };


 hsi2c_3: hsi2c@138C0000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x138C0000 0x1000>;
  interrupts = <0 451 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c3_bus>;
  clocks = <&clock 320>, <&clock 320>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpf0 2 0x1>;
  gpio_scl= <&gpf0 3 0x1>;
  status = "disabled";
 };


 hsi2c_4: hsi2c@138B0000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x138B0000 0x1000>;
  interrupts = <0 450 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c4_bus>;
  clocks = <&clock 322>, <&clock 322>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpf1 0 0x1>;
  gpio_scl= <&gpf1 1 0x1>;
  status = "disabled";
 };

 lpass: lpass@148F0000 {
  compatible = "samsung,exynos7570-lpass";
  reg = <0x0 0x148F0000 0x1040>;
  clocks = <&clock 740>,
   <&clock 711>,
   <&clock 703>;

  clock-names = "fout_aud_pll", "dout_sclk_mi2s",
    "dispaud_decon";

  samsung,syscon-phandle = <&pmu_system_controller>;
  samsung,power-domain = <&spd_aud>;
  status = "okay";
 };

 eax: eax {
  compatible = "samsung,exynos-amixer";
  status = "ok";
 };

 s1403x: s1403x@14880000 {
  compatible = "samsung,s1403x";
  reg = <0x0 0x14880000 0x200>;
  clocks = <&clock 742>,
   <&clock 710>;

  clock-names = "audmixer_dout", "audmixer_aclk";

  samsung,lpass-subip;
  status = "okay";
 };

 i2s0: i2s@148A0000 {
  compatible = "samsung,i2s-v5";
  reg = <0x0 0x148A0000 0x100>;
  dmas = <&pdma0 29
   &pdma0 30>;
  dma-names = "tx", "rx";
  interrupts = <0 69 0>;
  clocks = <&clock 711>,
   <&clock 741>,
   <&clock 741>;
  clock-names = "iis", "i2s_opclk0", "i2s_opclk1";
  samsung,amixer = <4>;
  samsung,supports-rstclr;
  samsung,supports-secdai;
  samsung,supports-esa-dma;
  samsung,i2s-str;
  samsung,lpass-subip;
  status = "disabled";
  i2s-sec {
   dmas = <&pdma0 28>;
   dma-names = "tx-sec";
   clocks = <&clock 711>,
    <&clock 741>,
    <&clock 741>;
   clock-names = "iis", "i2s_opclk0", "i2s_opclk1";
  };
 };

 i2s1: i2s@148B0000 {
  compatible = "samsung,i2s-v5";
  reg = <0x0 0x148B0000 0x100>;
  dmas = <&pdma0 31>;
  dma-names = "rx";
  interrupts = <0 71 0>;
  clocks = <&clock 712>,
   <&clock 741>,
   <&clock 741>;
  clock-names = "iis", "i2s_opclk0", "i2s_opclk1";
  samsung,supports-rstclr;
  samsung,i2s-str;
  samsung,supports-i2s-amp;
  samsung,lpass-subip;
  status = "disabled";
 };


 hsi2c_5: hsi2c@13910000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x13910000 0x1000>;
  interrupts = <0 459 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c5_bus>;
  clocks = <&clock 351>, <&clock 351>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpa1 7 0x1>;
  gpio_scl= <&gpa2 0 0x1>;
  status = "disabled";
 };


 hsi2c_6: hsi2c@13920000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x13920000 0x1000>;
  interrupts = <0 460 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c6_bus>;
  clocks = <&clock 351>, <&clock 351>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpa2 1 0x1>;
  gpio_scl= <&gpa2 2 0x1>;
  status = "disabled";
 };


 hsi2c_7: hsi2c@13930000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x13930000 0x1000>;
  interrupts = <0 463 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c7_bus>;
  clocks = <&clock 352>, <&clock 352>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpa2 4 0x1>;
  gpio_scl= <&gpa2 5 0x1>;
  status = "disabled";
 };


 hsi2c_8: hsi2c@13940000 {
  compatible = "samsung,exynos5-hsi2c";
  samsung,check-transdone-int;
  reg = <0x0 0x13940000 0x1000>;
  interrupts = <0 464 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&hs_i2c8_bus>;
  clocks = <&clock 352>, <&clock 352>;
  clock-names = "rate_hsi2c", "gate_hsi2c";
  samsung,scl-clk-stretching;
  gpio_sda= <&gpa2 6 0x1>;
  gpio_scl= <&gpa2 7 0x1>;
  status = "disabled";
 };


 amba {
  #address-cells = <2>;
  #size-cells = <1>;
  compatible = "arm,amba-bus";
  interrupt-parent = <&gic>;
  ranges;

  pdma0: pdma0@10490000 {
   compatible = "arm,pl330", "arm,primecell";
   reg = <0x0 0x10490000 0x1000>;
   interrupts = <0 383 0>;
   clocks = <&clock 50>;
   clock-names = "apb_pclk";
   #dma-cells = <1>;
   #dma-channels = <8>;
   #dma-requests = <32>;
  };
 };

 speedy@10510000 {
  compatible = "samsung,exynos-speedy";
  reg = <0x0 0x10510000 0x2000>;
  interrupts = <0 372 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&speedy_bus>;
  clocks = <&clock 11>;
  clock-names = "gate_speedy";
  status = "okay";
  samsung,always-interrupt-high;
 };


 spi_0: spi@100C0000 {
  compatible = "samsung,exynos-spi";
  reg = <0x0 0x100C0000 0x100>;
  samsung,spi-fifosize = <256>;
  interrupts = <0 434 0>;





  dma-names = "tx", "rx";
  swap-mode;
  #address-cells = <1>;
  #size-cells = <0>;
  clocks = <&clock 362>, <&clock 23>;
  clock-names = "spi", "spi_busclk0";
  pinctrl-names = "default";
  pinctrl-0 = <&spi0_bus>;
  status = "disabled";
 };


 spi_1: spi@13900000 {
  compatible = "samsung,exynos-spi";
  reg = <0x0 0x13900000 0x100>;
  samsung,spi-fifosize = <64>;
  interrupts = <0 433 0>;





  dma-names = "tx", "rx";
  swap-mode;
  #address-cells = <1>;
  #size-cells = <0>;
  clocks = <&clock 363>, <&clock 22>;
  clock-names = "spi", "spi_busclk0";
  pinctrl-names = "default";
  pinctrl-0 = <&spi1_bus>;
  status = "disabled";
 };


 spi_2: spi@13910000 {
  compatible = "samsung,exynos-spi";
  reg = <0x0 0x13910000 0x100>;
  samsung,spi-fifosize = <32>;
  interrupts = <0 462 0>;





  dma-names = "tx", "rx";
  swap-mode;
  #address-cells = <1>;
  #size-cells = <0>;
  clocks = <&clock 351>, <&clock 40>;
  clock-names = "spi", "spi_busclk0";
  pinctrl-names = "default";
  pinctrl-0 = <&spi2_bus>;
  status = "disabled";
 };


 spi_3: spi@13930000 {
  compatible = "samsung,exynos-spi";
  reg = <0x0 0x13930000 0x100>;
  samsung,spi-fifosize = <32>;
  interrupts = <0 466 0>;





  dma-names = "tx", "rx";
  swap-mode;
  #address-cells = <1>;
  #size-cells = <0>;
  clocks = <&clock 352>, <&clock 41>;
  clock-names = "spi", "spi_busclk0";
  pinctrl-names = "default";
  pinctrl-0 = <&spi3_bus>;
  status = "disabled";
 };

 secgpio_dvs {
  compatible = "samsung,exynos7570-secgpio-dvs";
  status = "okay";
 };

 dwmmc_0: dwmmc0@13540000 {
  compatible = "samsung,exynos-dw-mshc";
  reg = <0x0 0x13540000 0x2000>;
  interrupts = <0 245 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  clocks = <&clock 513>, <&clock 515>, <&clock 30>;
  clock-names = "biu", "ciu", "ciu_gate";
  status = "disabled";
  };

 dwmmc_2: dwmmc2@13560000 {
  compatible = "samsung,exynos-dw-mshc";
  reg = <0x0 0x13560000 0x2000>;
  interrupts = <0 247 0>;
  #address-cells = <1>;
  #size-cells = <0>;
  clocks = <&clock 514>, <&clock 516>, <&clock 31>;
  clock-names = "biu", "ciu", "ciu_gate";
  status = "disabled";
  };

 mali: mali@11400000 {
  compatible = "arm,mali";
  reg = <0x0 0x11400000 0x5000>;
  interrupts = <0 282 0>, <0 283 0>, <0 281 0>;
  interrupt-names = "JOB", "MMU", "GPU";
  clocks = <&clock 203>;
  clock-names = "vclk_g3d";
  samsung,power-domain = <&pd_g3d>;
 };

 mfc_0: mfc0@12C30000 {
  compatible = "samsung,mfc-v6";
  #pb-id-cells = <0>;
  reg = <0x0 0x12C30000 0x10000>;
  interrupts = <0 354 0>;
  clock-names = "aclk_mfc";
  clocks = <&clock 612>;
  samsung,power-domain = <&pd_mfcmscl>;
  status = "ok";
  ip_ver = <17>;
  clock_rate = <415000000>;
  min_rate = <100000>;
  num_qos_steps = <2>;
  mfc_qos_table {
   mfc_qos_variant_0 {
    thrd_mb = <0>;
    freq_mfc = <0>;
    freq_int = <415000>;
    freq_mif = <415000>;
    freq_cpu = <0>;
    freq_kfc = <0>;
    has_enc_table = <0>;
   };
   mfc_qos_variant_1 {
    thrd_mb = <244800>;
    freq_mfc = <0>;
    freq_int = <415000>;
    freq_mif = <666000>;
    freq_cpu = <0>;
    freq_kfc = <0>;
    has_enc_table = <0>;
   };
  };
 };

 mipi_phy_dsim: phy_m4s4_dsi@148F100C {

  compatible = "samsung,mipi-phy-dsim";
  reg = <0x0 0x148F100C 0x4>;
  samsung,pmu-syscon = <&pmu_system_controller>;
  isolation = <0x070C>;
  reset = <0>;
  #phy-cells = <1>;
 };

 mdev_0: mdev_output {
  compatible = "samsung,exynos5-mdev";
 };

 dsim_0: dsim@14800000 {
  compatible = "samsung,exynos8-mipi-dsi";
  reg = <0x0 0x14800000 0x100>;

  interrupts = <0 207 0>;
  samsung,power-domain = <&spd_disp>;

  phys = <&mipi_phy_dsim 0>;
  phy-names = "dsim_dphy";



  clocks = <&clock 704>,
         <&clock 721>,
         <&clock 720>;
  clock-names = "dsim_pclk", "dphy_escclk", "dphy_byteclk";


  data_lane_cnt = <4>;
 };

 decon_0: decon_fb@14830000 {
  compatible = "samsung,exynos5-decon_driver";
  #address-cells = <2>;
  #size-cells = <1>;
  ranges;

  reg = <0x0 0x14830000 0x8000>;
  #pb-id-cells = <0>;

  samsung,power-domain = <&spd_disp>;


  interrupts = <0 201 0>, <0 202 0>, <0 203 0>, <0 360 0>;

  clocks = <&clock 703>,
         <&clock 730>,
         <&clock 731>;
  clock-names = "decon_core", "vclk_user", "vclk_leaf";

  ip_ver = <4>;
  max_win = <3>;
  n_sink_pad = <3>;
  n_src_pad = <1>;
  default_win = <0>;
  trig_mode = <1>;
  dsi_mode = <0>;
# 1123 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-rev01.dtsi"
 };

 mailbox_cp: mcu_ipc@10500000 {
  compatible = "samsung,exynos-shd-ipc-mailbox";
  reg = <0x0 0x10500000 0x180>;
  mcu,name = "mcu_ipc_cp";
  mcu,id = <0>;
  interrupts = <0 369 0 >;
  mcu,irq_affinity_mask = <3>;
 };

 mailbox_gnss: mcu_ipc@10570000 {
  compatible = "samsung,exynos-shd-ipc-mailbox";
  reg = <0x0 0x10570000 0x180>;
  mcu,name = "mcu_ipc_gnss";
  mcu,id = <1>;
  interrupts = <0 373 0 >;
 };

 i2s0: i2s@148A0000 {
  compatible = "samsung,i2s-v5";
  reg = <0x0 0x148A0000 0x100>;
  interrupts = <0 69 0>;
  clocks = <&clock 711>,
   <&clock 741>,
   <&clock 741>;
  clock-names = "iis", "i2s_opclk0", "i2s_opclk1";
  samsung,supports-secdai;
  samsung,i2s-str;
  status = "disabled";
  i2s-sec {
   clocks = <&clock 711>,
    <&clock 741>,
    <&clock 741>;
   clock-names = "iis", "i2s_opclk0", "i2s_opclk1";
  };
 };

 gnss_pdata {
  compatible = "samsung,gnss_shdmem_if";
  shmem,name = "KEPLER";
  shmem,device_node_name = "gnss_ipc";
  status = "okay";

  interrupts = <0 19 0>, <0 478 0>, <0 477 0>;

  mbx,int_ap2gnss_bcmd = <0>;
  mbx,int_ap2gnss_req_fault_info = <1>;
  mbx,int_ap2gnss_ipc_msg = <2>;
  mbx,int_ap2gnss_ack_wake_set = <3>;
  mbx,int_ap2gnss_ack_wake_clr = <4>;

  mbx,irq_gnss2ap_bcmd = <0>;
  mbx,irq_gnss2ap_rsp_fault_info = <1>;
  mbx,irq_gnss2ap_ipc_msg = <2>;
  mbx,irq_gnss2ap_req_wake_clr = <4>;

  mbx,reg_bcmd_ctrl = <0>, <1>, <2>, <3>;

  reg_rx_ipc_msg = <1 5>;
  reg_tx_ipc_msg = <1 4>;
  reg_rx_head = <1 3>;
  reg_rx_tail = <1 2>;
  reg_tx_head = <1 1>;
  reg_tx_tail = <1 0>;
  fault_info = <1 0x100000 0x100000>;

  shmem,ipc_offset = <0x180000>;
  shmem,ipc_size = <0x80000>;
  shmem,ipc_reg_cnt = <32>;
 };

 cmu_fsys: cmu_fsys@0x13730000 {
  compatible = "samsung,exynos7570-cmu_fsys", "syscon";
  reg = <0x0 0x13730000 0x2000>;
 };

 scsc_wifibt: scsc_wifibt@10580000 {
  compatible = "samsung,scsc_wifibt";

  reg = <0x0 0x10580000 0x180>;
  interrupts = <0 376 4>, <0 21 4>, <0 476 4>;
  interrupt-names = "MBOX","ALIVE","WDOG";

  samsung,syscon-phandle = <&pmu_system_controller>;

  samsung,syscon-cmu_fsys = <&cmu_fsys>;
  usbpll,owner="y";
  usbpll,udelay=<20>;
  status = "okay";
 };

 iommu-domain_mfc_mscl {
  compatible = "samsung,exynos-iommu-bus";
  #address-cells = <2>;
  #size-cells = <1>;
  domain-clients = <&smfc>, <&scaler_0>, <&mfc_0>, <&fimc_is>, <&fimc_is_sensor0>, <&fimc_is_sensor1>;
  ranges;

  smfc: smfc@12C20000 {
   compatible = "samsung,exynos8890-jpeg";
   reg = <0x0 0x12C20000 0x2000>;
   interrupts = <0 404 0>;
   clocks = <&clock 611>;
   clock-names = "gate";
   samsung,power-domain = <&pd_mfcmscl>;
  };

  scaler_0: scaler@12C10000 {
   compatible = "samsung,exynos5-scaler";
   reg = <0x0 0x12C10000 0x1300>;
   interrupts = <0 401 0>;
   clocks = <&clock 610>;
   clock-names = "gate";
   samsung,power-domain = <&pd_mfcmscl>;
   prefetch-buffer,disable;
  };

  sysmmu_mfc_mscl: sysmmu@12C80000 {
   compatible = "samsung,exynos7420-sysmmu";
   reg = <0x0 0x12C80000 0x3000>;
   interrupts = <0 352 0>,
     <0 409 0>;
   clocks = <&clock (1100 + 0)>;
   clock-names = "aclk";
   samsung,power-domain = <&pd_mfcmscl>;
   sysmmu,v7tlb_property = <(0x2) ((0x2 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <(0x6) ((0x2 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <(0xE) ((0x2 << 5) | (0x1 << 2) | (0x1 << 1))>,
      <((0x22) + 0x8000) ((0x2 << 5) | (0x1 << 2) | (0x1 << 1))>,
      <((0x26) + 0x8000) ((0x2 << 5) | (0x1 << 2) | (0x1 << 1))>,
      <((0x2A) + 0x8000) ((0x2 << 5) | (0x1 << 2) | (0x1 << 1))>;
   sysmmu,secure_reg = <0x12C70000>;
   sysmmu,handle_secure-irq;
   master_ip_list = <&smfc>, <&scaler_0>, <&mfc_0>, <&fimc_is>;
  };

  sysmmu_isp: sysmmu@0x14470000 {
   compatible = "samsung,exynos7420-sysmmu";
   reg = <0x0 0x14470000 0x3000>;
   interrupts = <0 128 0>;
   qos = <15>;
   clocks = <&clock (1100 + 2)>;
   clock-names = "aclk";
   samsung,power-domain = <&pd_isp>;
   sysmmu,v7tlb_property = <((0x0) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <((0x4) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <(0x1) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <((0x1) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <((0x5) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <((0x2) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <((0x6) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <((0xA) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <((0x3) + 0x8000) ((0x0 << 5) | (0x2 << 2) | (0x1 << 1))>,
      <(0x3) ((0x1 << 5) | (0x0 << 1))>;
   master_ip_list = <&fimc_is>, <&fimc_is_sensor0>, <&fimc_is_sensor1>;
   };
 };

 iommu-domain_disp {
  compatible = "samsung,exynos-iommu-bus";
  #address-cells = <2>;
  #size-cells = <1>;
  ranges;

  domain-clients = <&decon_0>;

  sysmmu_disp: sysmmu@14860000 {
   compatible = "samsung,exynos7420-sysmmu";
   reg = <0x0 0x14860000 0x3000>;
   interrupts = <0 192 0>,
     <0 193 0>;
   qos = <15>;
   clocks = <&clock (1100 + 1)>;
   clock-names = "aclk";
   samsung,power-domain = <&pd_dispaud>;
   sysmmu,v7tlb_property = <(0x0) ((0x0 << 5) | (0x0 << 1))>,
      <(0x2) ((0x0 << 5) | (0x0 << 1))>,
      <(0x4) ((0x0 << 5) | (0x0 << 1))>,
      <(0x5) ((0x0 << 5) | (0x0 << 1))>;
   sysmmu,secure_reg = <0x14850000>;
   sysmmu,handle_secure-irq;
   master_ip_list = <&decon_0>;
  };
 };

 watchdog@10170000 {
  compatible = "samsung,exynos7-wdt";
  reg = <0x0 0x10170000 0x100>;
  interrupts = <0 100 0>;
  clocks = <&clock 371>, <&clock 371>;
  clock-names = "rate_watchdog", "gate_watchdog";
  timeout-sec = <30>;
  samsung,syscon-phandle = <&pmu_system_controller>;
 };

 exynos_adc: adc@10550000 {
  compatible = "samsung,exynos-adc-v3";
  reg = <0x0 0x10550000 0x1000>;
  interrupts = <0 395 0>;
  #io-channel-cells = <1>;
  io-channel-ranges;
  clocks = <&clock 10>;
  clock-names = "gate_adcif";
 };

 rtc@101A0000 {
  compatible = "samsung,s3c6410-rtc";
  reg = <0x0 0x101A0000 0x100>;
  interrupts = <0 92 0>, <0 93 0>;
  clocks = <&clock 374>;
  clock-names = "gate_rtc";
 };

 coresight@16000000 {
  compatible = "exynos,coresight";
  base = <0x16000000>;
  sjtag-offset = <0x6000>;

  cs_apollo0@400000 {
   device_type = "cs";
   dbg-offset = <0x410000>;
  };
  cs_apollo1@500000 {
   device_type = "cs";
   dbg-offset = <0x510000>;
  };
  cs_apollo2@600000 {
   device_type = "cs";
   dbg-offset = <0x610000>;
  };
  cs_apollo3@700000 {
   device_type = "cs";
   dbg-offset = <0x710000>;
  };
 };

 udc: usb@13600000 {
  compatible = "samsung,exynos7570-dwusb2";
  reg = <0x0 0x13600000 0x10000>;
  clocks = <&clock 512>;
  clock-names = "usbdrd20";
  #address-cells = <2>;
  #size-cells = <1>;
  ranges;
  status = "disabled";

  usbdrd_dwc3: dwc3 {
   compatible = "synopsys,dwc3";
   reg = <0x0 0x13600000 0x10000>;
   interrupts = <0 230 0>;
   maximum-speed = "high-speed";
   is_not_vbus_pad;
   suspend_clk_freq = <67000000>;
   enable_sprs_transfer;
   phys = <&usbdrd_phy 0>, <&usbdrd_phy 1>;
   phy-names = "usb2-phy", "usb3-phy";
  };
 };

 usbdrd_phy: usbphy@135c0000 {
  compatible = "samsung,exynos7570-usbdrd-phy";
  reg = <0x0 0x135c0000 0x100>;
  clocks = <&clock 512>, <&clock 520>, <&clock 530>;
  clock-names = "usbdrd20", "phyumux", "usb_pll";
  #phy-cells = <1>;
  samsung,pmu-syscon = <&pmu_system_controller>;
  is_not_vbus_pad;
  use_additional_tuning;
  request_extrefclk;
  uart_io_share_enable = <1>;
  uart_io_share_offset = <0x6200>;
  uart_io_share_mask = <0x1>;
  status = "disabled";
 };

 sec_pwm: pwm@13970000 {
  compatible = "samsung,s3c6400-pwm";
  reg = <0x0 0x13970000 0x1000>;
  samsung,pwm-outputs = <0>, <1>, <2>, <3>, <4>;
  samsung,pwm-sclk-ctrl;
  #pwm-cells = <3>;
  clocks = <&clock 330>, <&clock 331>,
   <&clock_pwm 1>, <&clock_pwm 2>,
   <&clock_pwm 5>, <&clock_pwm 6>,
   <&clock_pwm 7>, <&clock_pwm 8>,
   <&clock_pwm 10>, <&clock_pwm 11>,
   <&clock_pwm 12>, <&clock_pwm 13>;
  clock-names = "gate_timers", "sclk_pwm",
   "pwm-scaler0", "pwm-scaler1",
   "pwm-tdiv0", "pwm-tdiv1",
   "pwm-tdiv2", "pwm-tdiv3",
   "pwm-tin0", "pwm-tin1",
   "pwm-tin2", "pwm-tin3";
  status = "ok";
 };

 clock_pwm: pwm-clock-controller@13970000 {
  compatible = "samsung,exynos-pwm-clock";
  reg = <0x0 0x13970000 0x50>;
  #clock-cells = <1>;
 };

 mipi_phy_csis: phy_phy_csis@144F1040 {
  compatible = "samsung,mipi-phy-csis";
  reg = <0x0 0x144F1040 0x4>;
  samsung,pmu-syscon = <&pmu_system_controller>;
  isolation = <0x070C 0x0714>;
  reset = <1 0>;
  #phy-cells = <1>;
 };

 fimc_is_sensor0: fimc_is_sensor0@14420000 {

  compatible = "samsung,exynos5-fimc-is-sensor";
  #pb-id-cells = <0>;
  reg = <0x0 0x14420000 0x10000>,
    <0x0 0x14410000 0x10000>;
  interrupts = <0 144 0>,
    <0 137 0>;
  samsung,power-domain = <&pd_isp>;

  phys = <&mipi_phy_csis 1>;
  phy-names = "csis_dphy";
  clock-names =
   "mif_isp_sensor0";
  clocks = <&clock 43>;
 };

 fimc_is_sensor1: fimc_is_sensor1@14420000 {

  compatible = "samsung,exynos5-fimc-is-sensor";
  #pb-id-cells = <0>;
  reg = <0x0 0x14420000 0x10000>,
    <0x0 0x14410000 0x10000>;
  interrupts = <0 144 0>,
    <0 137 0>;
  samsung,power-domain = <&pd_isp>;

  phys = <&mipi_phy_csis 0>;
  phy-names = "csis_dphy";
  clock-names =
   "mif_isp_sensor0";
  clocks = <&clock 43>;
 };

 fimc_is: fimc_is@14400000 {
  compatible = "samsung,exynos5-fimc-is";
  #pb-id-cells = <0>;
  reg = <0x0 0x14400000 0xC400>,
    <0x0 0x14430000 0x2000>,
    <0x0 0x14440000 0x10000>,
    <0x0 0x14450000 0x10000>,
    <0x0 0x14480000 0xC400>,
    <0x0 0x12C00000 0x2000>;

  interrupts = <0 139 0>,
    <0 140 0>,
    <0 141 0>,
    <0 142 0>,
    <0 146 0>,
    <0 400 0>;
  samsung,power-domain = <&pd_isp>;

  clock-names =
   "oscclk",
   "isp_ppmu",
   "isp_bts",
   "isp_cam",
   "isp_vra",
   "umux_isp_clkphy_isp_s_rxbyteclkhs0_s4_user",
   "gate_mscl",
   "mif_isp_sensor0";
  clocks = <&clock 1>,
   <&clock 801>,
   <&clock 802>,
   <&clock 803>,
   <&clock 804>,
   <&clock 810>,
   <&clock 610>,
   <&clock 43>;

  status = "ok";
 };

 fm@14840000 {
  compatible = "samsung,exynos7570-fm";
  reg = <0x0 0x14840000 0x2000>,
   <0x0 0x11C80000 0x1000>,
   <0x0 0x10580000 0x100>,
   <0x0 0x148D0000 0x500>,
   <0x0 0x10460000 0x3000>,
   <0x0 0x13730000 0x2000>,
   <0x0 0x14880000 0x100>;
  interrupts = <0 195 0>;
  clocks = <&clock 743>;
  clock-names = "oscclk_fm_52m_div";
  samsung,syscon-phandle = <&pmu_system_controller>;
  samsung,power-domain = <&spd_fm>;
  status = "okay";
 };

 exynos-powermode {
  compatible = "exynos,powermode";





  wakeup_mask = <0x400F91E1>, <0x0>, <0x0>, <0x0>,
          <0x0>, <0x0>, <0x0>, <0x0>,
          <0x400FFFFE>;
  wakeup_mask2 = <0x0>, <0x0>, <0x0>, <0x0>,
          <0x0>, <0x0>, <0x0>, <0x0>,
          <0xFFFF00FF>;
  wakeup_mask3 = <0x0>, <0x0>, <0x0>, <0x0>,
          <0x0>, <0x0>, <0x0>, <0x0>,
          <0xFFFF00FF>;

  cpd_residency = <3000>;
  sicd_residency = <3000>;

  sicd_enabled = <0>;

  idle-ip = "136c0000.pwm",
     "10550000.adc",

     "10510000.hsi2c",
     "13950000.hsi2c",
     "13960000.hsi2c",
     "138a0000.hsi2c",
     "138b0000.hsi2c",
     "138c0000.hsi2c",
     "138f0000.hsi2c",

     "13870000.i2c",
     "13880000.i2c",
     "13890000.i2c",
     "13840000.i2c",
     "13830000.i2c",
     "138d0000.i2c",
     "138e0000.i2c",
     "13850000.i2c",
     "13860000.i2c",

     "13540000.dwmmc0",
     "13560000.dwmmc2",

     "13600000.usb",

     "100c0000.spi",
     "13900000.spi",
     "13910000.spi",
     "13920000.spi",
     "13930000.spi",

     "10500000.mailbox-cp",
     "10570000.mailbox-gnss",

     "14830000.decon_fb",
     "pd-g3d",
     "pd-isp",
     "pd-mfcmscl",
     "148f0000.lpass";
  idle_ip_mask {
   sicd: SYS_SICD {
    mode-index = <0>;
    ref-idle-ip = <0>, <1>, <2>, <3>, <4>, <5>, <6>, <7>, <8>, <9>,
          <10>, <11>, <12>, <13>, <14>, <15>, <16>, <17>, <18>, <19>,
          <20>, <21>, <22>, <23>, <24>, <25>, <26>, <27>, <28>, <29>,
          <30>, <31>, <32>;
   };
  };
 };

 fips-fmp {
  compatible = "samsung,exynos-fips-fmp";
 };
};
# 13 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xe_common.dtsi" 2

/ {
 model = "Samsung ON5XELTE board based on EXYNOS7570";
 compatible = "samsung,exynos7570", "samsung,exynos4210";

 memory@40000000 {
  device_type = "memory";
  reg = <0x0 0x40000000 0x3E800000>;
 };

 memory@80000000 {
  device_type = "memory";
  reg = <0x0 0x80000000 0x40000000>;
 };

 chosen {
  bootargs = "console=ttySAC2,115200 clk_ignore_unused androidboot.hardware=samsungexynos7570 androidboot.selinux=disabled firmware_class.path=/vendor/firmware ess_setup=0x46000000 bcm_setup=0xffffff80f8e00000 androidboot.debug_level=0x4948 reserve-fimc=0";
  linux,initrd-start = <0x42000000>;
  linux,initrd-end = <0x421FFFFF>;
 };

 fixed-rate-clocks {
  oscclk {
   compatible = "samsung,exynos7570-oscclk";
   clock-frequency = <26000000>;
  };
 };

 firmware {
  android {
   compatible = "android,firmware";
   fstab {
    compatible = "android,fstab";
    system {
     compatible = "android,system";
     dev = "/dev/block/platform/13540000.dwmmc0/by-name/SYSTEM";
     type = "ext4";
     mnt_flags = "ro";
     fsmgr_flags = "wait";
    };
   };
  };
 };


 serial_2: uart@13820000 {
  status = "okay";
 };

 dwmmc0@13540000 {
  status = "okay";
  num-slots = <1>;
  broken-card-detect;
  use-smu;
  fixed_voltage;
  supports-highspeed;
  clock-gate;
  mmc-ddr-1_8v;
  mmc-hs200-1_8v;
  mmc-hs400-1_8v;
  supports-8bit;
  supports-cmd23;
  supports-erase;
  enable-ulp-mode;
  supports-hs400-enhanced-strobe;
  pm-skip-mmc-resume-init;
  mmc_pwr_shut_down;
  card-init-hwacg-ctrl;
  fifo-depth = <0x40>;
  non-removable;
  desc-size = <4>;
  card-detect-delay = <200>;
  data-timeout = <200>;
  hto-timeout = <80>;
  clock-frequency = <700000000>;
  samsung,dw-mshc-ciu-div = <3>;
  samsung,dw-mshc-txdt-crc-timer-fastlimit = <0x34>;
  samsung,dw-mshc-txdt-crc-timer-initval = <0x38>;
  samsung,dw-mshc-ddr200-delay-line = <0x60>;
  samsung,dw-mshc-sdr-timing = <3 0 2 0>;
  samsung,dw-mshc-ddr-timing = <3 0 4 2>;
  samsung,dw-mshc-hs200-timing = <3 0 3 0>;
  samsung,dw-mshc-ddr200-timing = <1 0 4 0>;
  samsung,dw-mshc-ddr200-ulp-timing = <3 0 3 0>;

  num-ref-clks = <12>;
  ciu_clkin = <25 43 43 25 43 87 175 43 43 175 175 175>;


  clk-drive-number = <4>;
  pinctrl-names = "default",
   "fast-slew-rate-1x",
   "fast-slew-rate-2x",
   "fast-slew-rate-3x",
   "fast-slew-rate-4x";
  pinctrl-0 = <&sd0_clk &sd0_cmd &sd0_rdqs &sd0_bus1 &sd0_bus4 &sd0_bus8>;
  pinctrl-1 = <&sd0_clk_fast_slew_rate_1x>;
  pinctrl-2 = <&sd0_clk_fast_slew_rate_2x>;
  pinctrl-3 = <&sd0_clk_fast_slew_rate_3x>;
  pinctrl-4 = <&sd0_clk_fast_slew_rate_4x>;
  slot@0 {
   reg = <0>;
   bus-width = <8>;
  };
 };

 dwmmc2@13560000 {
  status = "okay";
  num-slots = <1>;
  clock-gate;
  supports-highspeed;
  supports-4bit;
  supports-cmd23;
  supports-erase;
  sd-uhs-sdr50;
  sd-uhs-sdr104;
  card-detect-gpio;
  bypass-smu;
  only_once_tune;
  bypass-for-allpass;
  use-fine-tuning;
  skip-init-mmc-scan;
  card-init-hwacg-ctrl;
  switch_transfer;
  ignore-phase = <(1 << 7)>;
  fifo-depth = <0x40>;
  desc-size = <4>;
  card-detect-delay = <200>;
  data-timeout = <200>;
  hto-timeout = <80>;
  clock-frequency = <700000000>;
  samsung,dw-mshc-ciu-div = <3>;
  samsung,dw-mshc-sdr-timing = <3 0 2 0>;
  samsung,dw-mshc-ddr-timing = <3 0 2 1>;
  samsung,dw-mshc-sdr50-timing = <3 0 4 2>;
  samsung,dw-mshc-sdr104-timing = <3 0 3 0>;

  num-ref-clks = <9>;
  ciu_clkin = <25 43 43 25 43 87 175 43 43>;

  clk-drive-number = <4>;
  pinctrl-names = "default",
   "fast-slew-rate-1x",
   "fast-slew-rate-2x",
   "fast-slew-rate-3x",
   "fast-slew-rate-4x";
  pinctrl-0 = <&sd2_clk &sd2_cmd &sd2_bus1 &sd2_bus4 &dwmmc2_cd_ext_irq>;
  pinctrl-1 = <&sd2_clk_fast_slew_rate_1x>;
  pinctrl-2 = <&sd2_clk_fast_slew_rate_2x>;
  pinctrl-3 = <&sd2_clk_fast_slew_rate_3x>;
  pinctrl-4 = <&sd2_clk_fast_slew_rate_4x>;

  card-detect = <&gpa0 1 0xf>;
  sec-sd-slot-type = <2>;
  slot@0 {
   reg = <0>;
   bus-width = <4>;
   disable-wp;
  };
 };

 ion {
  compatible = "samsung,exynos5430-ion";
 };

 pinctrl@139C0000 {
  i2c2_bus: i2c2-bus {
   samsung,pins = "gpc2-1", "gpc2-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
 };

 i2c_2: i2c@13890000 {
  status = "okay";
  samsung,i2c-max-bus-freq = <400000>;

  isl98611@29 {
   compatible = "i2c,isl98611";
   reg = <0x29>;
  };
 };

 decon_fb@14830000 {
  psr_mode = <0>;

  mif-vclk = <200000000>;

  disp-vclk = <200000000>;



  vclk-num = <1024>;

  vclk-denom = <621>;


  disp-dvfs = <208000000>;
 };

 dsim_0: dsim@14800000 {
  lcd_info = <&td4100>;
  decon_board = <&decon_board>;
  status = "okay";


  data_lane_cnt = <4>;
  enable_early_gpio = <&gpa1 3 0x00>, <&gpa0 4 0xf>;
 };

 decon_board: decon_board {
  gpio_blic_on = <&gpa1 2 0x1>;
  gpio_panel_enp = <&gpa2 0 0x1>;
  gpio_panel_enn = <&gpa2 1 0x1>;
  gpio_lcd_rst = <&gpd2 0 0x1>;

  dsim_set_panel_power_early {
   type =
   "regulator,enable", "LCD_1P8",
   "delay,usleep", "1000 2000";
  };
  dsim_set_panel_power_enable {
   type =
   "gpio,high", "gpio_blic_on",
   "delay,usleep", "1000 2000",
   "gpio,high", "gpio_panel_enp",
   "delay,usleep", "1000 2000",
   "gpio,high", "gpio_panel_enn",
   "delay,usleep", "10000 11000";
  };
  dsim_set_panel_power_disable {
   type =
   "delay,usleep", "5000 6000",
   "gpio,low", "gpio_panel_enn",
   "delay,usleep", "5000 6000",
   "gpio,low", "gpio_panel_enp",
   "delay,usleep", "15000 16000",
   "gpio,low", "gpio_lcd_rst",
   "delay,usleep", "5000 6000",
   "gpio,low", "gpio_blic_on",
   "delay,usleep", "10000 11000",
   "regulator,disable", "LCD_1P8";
  };
  dsim_reset_panel {
   type =
   "gpio,high", "gpio_lcd_rst",
   "delay,usleep", "1000 1100",
   "gpio,low", "gpio_lcd_rst",
   "delay,usleep", "1000 1100",
   "gpio,high", "gpio_lcd_rst",
   "timer,start", "reset 130";
  };
  dsim_reset_panel_wait {
   type =
   "timer,delay", "reset";
  };
  td4100_init {
   type =
   "timer,start", "sleep_out 100";
  };
  td4100_displayon_late {
   type =
   "timer,delay", "sleep_out";
  };
 };

 td4100: td4100_hd {
  mode = <0>;

  panel_name = "td4100";
  resolution = <720 1280>;
  dispif_resol = <720 1280>;
  size = <62 110>;
  timing,refresh = <60>;


  timing,dsim_h-porch = <25 210 25>;

  timing,dsim_v-porch = <13 400 2>;


  timing,decon_h-porch = <25 423 25>;


  timing,decon_v-porch = <13 400 2>;
  timing,dsi-hs-clk = <728>;
  timing,pms = <2 112 1>;
  timing,dsi-escape-clk = <16>;
 };

 usb@13600000 {
  status = "okay";

  dwc3 {
   dr_mode = "otg";
  };
 };

 usbphy@135c0000 {
  status = "okay";
  hs_tune_info = <&usb_hs_tune>;
  ss_tune_info = <&usb_ss_tune>;
 };

 usb_hs_tune:hs_tune {
  status = "okay";

  tx_vref = <0x3 0x3>;
  tx_pre_emp = <0x0 0x0>;
  tx_pre_emp_puls = <0x0 0x0>;
  tx_res = <0x2 0x2>;
  tx_rise = <0x1 0x1>;
  tx_hsxv = <0x0 0x0>;
  tx_fsls = <0x3 0x3>;
  rx_sqrx = <0x5 0x5>;
  compdis = <0x3 0x3>;
  otg= <0x2 0x2>;


  enable_user_imp = <0 0>;

  is_phyclock = <1>;
 };

 usb_ss_tune:ss_tune {
  status = "disabled";

  tx_boost_level = <0x4 0x4>;
  tx_swing_level = <0x1 0x1>;
  tx_swing_full = <0x7F 0x7F>;
  tx_swing_low = <0x7F 0x7F>;
  tx_deemphasis_mode = <0x1 0x1>;
  tx_deemphasis_3p5db = <0x18 0x18>;
  tx_deemphasis_6db = <0x18 0x18>;
  enable_ssc = <0x1 0x1>;
  ssc_range = <0x0 0x1>;
  los_bias = <0x5 0x5>;
  los_mask_val = <0x104 0x104>;
  enable_fixed_rxeq_mode = <0x0 0x0>;
  fix_rxeq_value = <0x4 0x4>;
  set_crport_mpll_charge_pump = <0x0 0x0>;
  set_crport_level_en = <0x0 0x0>;
 };

 usb_notifier {
  compatible = "samsung,usb-notifier";
  udc = <&udc>;
 };

 tmuctrl_0: tmuctrl_CPUCL0@10130000 {
  compatible = "samsung,exynos7570-tmu";
  reg = <0x0 0x10130000 0x200>;
  interrupts = <0 435 0>;
  default_ptat_cont = <0x1>;
 };

 tmuctrl_1: tmuctrl_G3D@10130000 {
  compatible = "samsung,exynos7570-tmu";
  reg = <0x0 0x10130000 0x200>;
  interrupts = <0 435 0>;
  default_ptat_cont = <0x1>;


  gpu_idx_num = <5>;

  gpu_cooling_table = < 0 0 830000
          0 1 666000
          0 2 553000
          0 3 415000
          0 4 (~1)>;
 };

 pinctrl@139F0000 {
  key_volup: key-volup {
   samsung,pins = "gpa0-7";
   samsung,pin-function = <0xf>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  key_voldown: key-voldown {
   samsung,pins = "gpa2-3";
   samsung,pin-function = <0xf>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  key_home: key-home {
   samsung,pins = "gpa0-4";
   samsung,pin-function = <0xf>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

  if_irq: if-irq {
   samsung,pins = "gpa0-5";
   samsung,pin-pud = <3>;
   samsung,pin-drv = <3>;
  };

  muic_irq: muic-irq {
   samsung,pins = "gpa1-1";
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };

  if_con_sense_int: if-con-sense-int {
   samsung,pins = "gpa0-6";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
  };
 };

 pinctrl@139C0000 {
  svcled_en: svcled_en {
   samsung,pins = "gpc2-2";
   samsung,pin-function = <1>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };
 };

 usi_1: usi@101D3000 {
  usi_mode = "hsi2c1";
  status = "okay";
 };

 hsi2c_8: hsi2c@13940000 {
  status = "okay";
  ktd2026@30 {
   compatible = "ktd2026";
   reg=<0x30>;
   pinctrl-names = "default";

   svcled_en = <&gpc2 2 0x0>;

   led_conf@1 {
    led_conf-name = "led_r";
    brightness = <0>;
    max_brightness = /bits/ 8 <0x19>;
    max_brightness2 = /bits/ 8 <0x1C>;
    max_brightness3 = /bits/ 8 <0x1C>;
    flags = <0>;
   };
   led_conf@2 {
    led_conf-name = "led_g";
    brightness = <0>;
    max_brightness = /bits/ 8 <0x04>;
    max_brightness2 = /bits/ 8 <0x05>;
    max_brightness3 = /bits/ 8 <0x06>;
    flags = <0>;
   };
   led_conf@3 {
    led_conf-name = "led_b";
    brightness = <0>;
    max_brightness = /bits/ 8 <0x2D>;
    max_brightness2 = /bits/ 8 <0x3C>;
    max_brightness3 = /bits/ 8 <0x4B>;
    flags = <0>;
   };
  };
 };

 gpio_keys {
  compatible = "gpio-keys";
  pinctrl-names = "default";
  pinctrl-0 = <&key_voldown &key_volup &key_home>;
  #address-cells = <1>;
  #size-cells = <0>;

  button@1 {
   label = "gpio-keys: KEY_VOLUMEUP";
   interrupts = <7 0 0>;
   interrupt-parent = <&gpa0>;
   linux,code = <115>;
   gpios = <&gpa0 7 0xf>;
  };
  button@2 {
   label = "gpio-keys: KEY_HOME";
   interrupts = <4 0 0>;
   interrupt-parent = <&gpa0>;
   linux,code = <172>;
   gpios = <&gpa0 4 0xf>;
   gpio-key,wakeup = <1>;
  };
  button@3 {
   label = "gpio-keys: KEY_VOLUMEDOWN";
   interrupts = <3 0 0>;
   interrupt-parent = <&gpa2>;
   linux,code = <114>;
   gpios = <&gpa2 3 0xf>;
  };
 };

 pinctrl@139D0000 {
  attn_irq: attn-irq {
   samsung,pins = "gpc3-2";
   samsung,pin-function = <0xf>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
  attn_input: attn-input {
   samsung,pins = "gpc3-2";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
 };

 pinctrl@148C0000 {
  i2s_pmic_bus: i2s-pmic-bus {
   samsung,pins = "gpz1-0", "gpz1-2", "gpz1-3";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };

  i2s_pmic_bus_idle: i2s-pmic-bus-idle {
   samsung,pins = "gpz1-0", "gpz1-2", "gpz1-3";
   samsung,pin-function = <0>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };
 };

 pinctrl@139B0000 {
  i2c4_bus: i2c4-bus {
   samsung,pins = "gpc4-1", "gpc4-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };

 };

 pinctrl@139F0000 {
  tkey_irq: tkey-irq {
   samsung,pins = "gpa0-2";
   samsung,pin-function = <0xf>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
  tkey_input: tkey-input {
   samsung,pins = "gpa0-2";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
 };

 i2c@13830000 {
  samsung,i2c-sda-delay = <100>;
  samsung,i2c-max-bus-freq = <400000>;
  status = "okay";
  mip4_tk@49{
   compatible = "melfas,mip4_tk";
   reg = <0x49>;
   pinctrl-names = "default", "on_state","off_state";
   pinctrl-0 = <&tkey_irq>;
   pinctrl-1 = <&tkey_irq>;
   pinctrl-2 = <&tkey_input>;
   mip4_tk,keynum = <2>;
   mip4_tk,keycode = <254 158>;
   mip4_tk,irq-gpio = <&gpa0 2 0>;
   mip4_tk,pwr-reg-name = "touchkey_3p0";
   mip4_tk,boot-on-ldo = <1>;
   mip4_tk,firmware-name = "melfas_tk/mhs204_on5xlte.fw";
  };
 };


 pinctrl@139D0000 {


  i2c3_bus: i2c3-bus {
   samsung,pins = "gpc3-1", "gpc3-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };
  i2c_on: i2c-on {
   samsung,pins = "gpc3-1", "gpc3-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
  i2c_off: i2c-off {
   samsung,pins = "gpc3-1", "gpc3-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };
  attn_input: attn-input {
   samsung,pins = "gpc3-2";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
  attn_irq: attn-irq {
   samsung,pins = "gpc3-2";
   samsung,pin-function = <0xf>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
 };

 i2c@13840000 {
  status = "okay";
  #address-cells = <1>;
  #size-cells = <0>;
  samsung,i2c-max-bus-freq = <400000>;
  touchscreen@4b {
   compatible = "synaptics,rmi4";
   reg = <0x4b>;
   pinctrl-names = "default", "on_state", "off_state";
   pinctrl-0 = <&attn_irq>;
   pinctrl-1 = <&i2c_on>;
   pinctrl-2 = <&i2c_off>;
   synaptics,irq_gpio = <&gpc3 2 0>;
   synaptics,irq_type = <8200>;
   synaptics,max_coords = <720 1280>;
   synaptics,num_lines = <29 16>;
   synaptics,project_name = "On5x","G570";
   synaptics,ub-i2c-addr = <0x2c>;
   synaptics,reset-delay-ms = <150>;
   synaptics,firmware_name = "tsp_synaptics/td4100_on5xlte.fw";
   synaptics,firmware_name_bl = "tsp_synaptics/td4100_on5xlte_recovery.fw";
  };
 };

 i2c@13880000 {
  status = "okay";

  muic-universal@14 {
   status = "okay";
   compatible = "muic-universal";
   reg = <0x14>;
   pinctrl-names = "default";
   pinctrl-0 = <&muic_irq>;
   muic-universal,chip_name = "sm,sm5504";
   muic-universal,irq-gpio = <&gpa1 1 0>;
  };
 };

 muic {
  status = "okay";
  muic,support-list = "+OTG:GND",
     "-MHL:1K",
     "-VZW Accessory:28.7K",
     "-VZW Incompatible:34K",
     "-Smartdock:40.2K",
     "-HMT:49.9K",
     "-Audiodock:64.9K",
     "-USB LANHUB:80.07K",
     "-Charging Cable:102K",
     "-Universal Multimedia dock:121K",
     "+Jig USB Off:255K",
     "+Jig USB On:301K",
     "+Deskdock:365K",
     "+TYPE2 Charger:442K",
     "+Jig UART Off:523K",
     "+Jig UART On:619K",
     "+TA:OPEN",
     "+USB:OPEN",
     "+CDP:OPEN",
     "+Undefined Charging:XXX";

 };


 pinctrl@139E0000 {
  gpc7: gpc7 {
   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };


  spi0_bus: spi0-bus {
   samsung,pins = "gpc7-3", "gpc7-2", "gpc7-1", "gpc7-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <3>;
   samsung,pin-drv = <0>;
  };
  spi0_bus_inactive: spi0-bus-inactive {
   samsung,pins = "gpc7-3", "gpc7-2", "gpc7-1", "gpc7-0";
   samsung,pin-function = <2>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };
 };

 pinctrl@139F0000 {
  acc_int: acc_int {
   samsung,pins = "gpa2-2";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };

  prox_int: prox_int {
   samsung,pins = "gpa1-0";
   samsung,pin-function = <0x0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <0>;
  };
 };

 i2c@138D0000 {
  samsung,i2c-sda-delay = <100>;
  samsung,i2c-max-bus-freq = <400000>;
  status = "okay";
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";

  stk3013@48 {
   compatible = "stk,stk3013";
   reg = <0x48>;
   interrupt-parent = <&gpa1>;
   interrupts = <0 0 0>;
   pinctrl-names = "default";
   pinctrl-0 = <&prox_int>;
   stk,vdd-supply = <&ldo22_reg>;
   stk,irq-gpio = <&gpa1 0 0x00>;
   stk,state-reg = <0x2d>;
   stk,psctrl-reg = <0x70>;
   stk,alsctrl-reg = <0x2A>;
   stk,ledctrl-reg = <0xFF>;
   stk,wait-reg = <0x03>;
   stk,ps-thd-h = <30>;
   stk,ps-thd-l = <20>;
   stk,ps-cancel-thd-h = <10>;
   stk,ps-cancel-thd-l = <7>;
   stk,ps-cal-skip-adc = <8>;
   stk,ps-cal-fail-adc = <17>;
   stk,ps-default-offset = <0>;
   stk,transmittance = <500>;
  };

  k2hh-i2c@1D {
   compatible = "k2hh-i2c";
   reg = <0x1D>;
   pinctrl-names = "default";
   pinctrl-0 = <&acc_int>;
   interrupt-parent = <&gpa2>;
   interrupts = <6 0 0>;
   k2hh,irq_gpio = <&gpa2 2 0>;
   k2hh,axis_map_x = <0>;
   k2hh,axis_map_y = <1>;
   k2hh,axis_map_z = <2>;
   k2hh,negate_x = <0>;
   k2hh,negate_y = <0>;
   k2hh,negate_z = <1>;
   k2hh,poll_interval = <100>;
   k2hh,min_interval = <2>;
  };
 };

 fimc_is@14400000 {
  vender {
   rear_sensor_id = <110>;
   front_sensor_id = <17>;
   use_module_check;

   total_camera_num = <2>;
   camera_info0 {
    isp = <0>;
    cal_memory = <2>;
    read_version = <0>;

    core_voltage = <0>;
    upgrade = <0>;
    companion = <0>;
    ois = <0>;
   };
   camera_info1 {
    isp = <0>;
    cal_memory = <3>;
    read_version = <0>;

    core_voltage = <0>;
    upgrade = <0>;
    companion = <0>;
    ois = <0>;
   };
  };

  fimc_is_dvfs {
# 817 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xe_common.dtsi"
   table0 {
    desc = "HAL1 version";

    default_int = <467000>;
    default_cam = <554000>;
    default_mif = <830000>;
    default_i2c = <0>;

    front_preview_int = <467000>;
    front_preview_cam = <444000>;
    front_preview_mif = <830000>;
    front_preview_i2c = <0>;

    front_capture_int = <467000>;
    front_capture_cam = <444000>;
    front_capture_mif = <830000>;
    front_capture_i2c = <0>;

    front_video_int = <467000>;
    front_video_cam = <554000>;
    front_video_mif = <830000>;
    front_video_i2c = <0>;

    front_video_capture_int = <467000>;
    front_video_capture_cam = <554000>;
    front_video_capture_mif = <830000>;
    front_video_capture_i2c = <0>;

    front_vt1_int = <467000>;
    front_vt1_cam = <444000>;
    front_vt1_mif = <830000>;
    front_vt1_i2c = <0>;

    front_vt2_int = <467000>;
    front_vt2_cam = <444000>;
    front_vt2_mif = <830000>;
    front_vt2_i2c = <0>;

    rear_preview_int = <467000>;
    rear_preview_cam = <554000>;
    rear_preview_mif = <830000>;
    rear_preview_i2c = <0>;

    rear_capture_int = <467000>;
    rear_capture_cam = <554000>;
    rear_capture_mif = <830000>;
    rear_capture_i2c = <0>;

    rear_video_int = <467000>;
    rear_video_cam = <554000>;
    rear_video_mif = <830000>;
    rear_video_i2c = <0>;

    rear_video_capture_int = <467000>;
    rear_video_capture_cam = <554000>;
    rear_video_capture_mif = <830000>;
    rear_video_capture_i2c = <0>;

    preview_high_speed_fps_int = <467000>;
    preview_high_speed_fps_cam = <554000>;
    preview_high_speed_fps_mif = <830000>;
    preview_high_speed_fps_i2c = <0>;

    video_high_speed_60fps_int = <467000>;
    video_high_speed_60fps_cam = <554000>;
    video_high_speed_60fps_mif = <830000>;
    video_high_speed_60fps_i2c = <0>;

    video_high_speed_120fps_int = <467000>;
    video_high_speed_120fps_cam = <554000>;
    video_high_speed_120fps_mif = <830000>;
    video_high_speed_120fps_i2c = <0>;

    max_int = <467000>;
    max_cam = <666000>;
    max_mif = <830000>;
    max_i2c = <0>;
   };

   table1 {
    desc = "HAL3 version";

    default_int = <467000>;
    default_cam = <554000>;
    default_mif = <830000>;
    default_i2c = <0>;

    front_preview_int = <467000>;
    front_preview_cam = <444000>;
    front_preview_mif = <830000>;
    front_preview_i2c = <0>;

    front_capture_int = <467000>;
    front_capture_cam = <444000>;
    front_capture_mif = <830000>;
    front_capture_i2c = <0>;

    front_video_int = <467000>;
    front_video_cam = <444000>;
    front_video_mif = <830000>;
    front_video_i2c = <0>;

    front_video_capture_int = <467000>;
    front_video_capture_cam = <444000>;
    front_video_capture_mif = <830000>;
    front_video_capture_i2c = <0>;

    front_vt1_int = <467000>;
    front_vt1_cam = <444000>;
    front_vt1_mif = <830000>;
    front_vt1_i2c = <0>;

    front_vt2_int = <467000>;
    front_vt2_cam = <444000>;
    front_vt2_mif = <830000>;
    front_vt2_i2c = <0>;

    rear_preview_int = <467000>;
    rear_preview_cam = <554000>;
    rear_preview_mif = <830000>;
    rear_preview_i2c = <0>;

    rear_capture_int = <467000>;
    rear_capture_cam = <554000>;
    rear_capture_mif = <830000>;
    rear_capture_i2c = <0>;

    rear_video_int = <467000>;
    rear_video_cam = <554000>;
    rear_video_mif = <830000>;
    rear_video_i2c = <0>;

    rear_video_capture_int = <467000>;
    rear_video_capture_cam = <554000>;
    rear_video_capture_mif = <830000>;
    rear_video_capture_i2c = <0>;

    preview_high_speed_fps_int = <467000>;
    preview_high_speed_fps_cam = <554000>;
    preview_high_speed_fps_mif = <830000>;
    preview_high_speed_fps_i2c = <0>;

    video_high_speed_60fps_int = <467000>;
    video_high_speed_60fps_cam = <554000>;
    video_high_speed_60fps_mif = <830000>;
    video_high_speed_60fps_i2c = <0>;

    video_high_speed_120fps_int = <467000>;
    video_high_speed_120fps_cam = <554000>;
    video_high_speed_120fps_mif = <830000>;
    video_high_speed_120fps_i2c = <0>;

    max_int = <467000>;
    max_cam = <666000>;
    max_mif = <830000>;
    max_i2c = <0>;
   };
  };
 };

 fimc_is_module_imx258: fimc-is_sensor_imx258@1A {
  compatible = "samsung,sensor-module-imx258";

  pinctrl-names = "pin0", "pin1", "pin2";
  pinctrl-0 = <>;
  pinctrl-1 = <&fimc_is_mclk0_in &fimc_is_flash>;
  pinctrl-2 = <&fimc_is_mclk0_fn &fimc_is_flash>;

  position = <0>;
  id = <0>;
  mclk_ch = <0>;
  sensor_i2c_ch = <0>;
  sensor_i2c_addr = <0x34>;

  gpio_reset = <&gpd1 1 0x1>;
  status = "okay";

  af {
   product_name = <13>;
   i2c_addr = <0x0C>;
   i2c_ch = <1>;
  };


  flash {
   product_name = <13>;
   flash_first_gpio = <2>;
   flash_second_gpio = <1>;
  };
 };

 fimc_is_module_5e3: fimc-is_sensor_5e3@10 {
  compatible = "samsung,sensor-module-5e3";

  pinctrl-names = "pin0", "pin1", "pin2";
  pinctrl-0 = <>;
  pinctrl-1 = <&fimc_is_mclk0_in>;
  pinctrl-2 = <&fimc_is_mclk0_fn>;

  position = <1>;
  id = <1>;
  mclk_ch = <0>;
  sensor_i2c_ch = <0>;
  sensor_i2c_addr = <0x10>;

  gpio_reset = <&gpd1 6 0x1>;
  status = "okay";
 };

 hsi2c_2: hsi2c@138A0000 {
   gpios = <&gpf0 0 0 &gpf0 1 0>;
   status = "okay";
   clock-frequency = <400000>;

   pinctrl-names = "default", "on_i2c";
   pinctrl-0 = <&hs_i2c2_bus>;
   pinctrl-1 = <&hs_i2c2_bus>;

   fimc-is-imx258@1A {
    compatible = "samsung,exynos5-fimc-is-cis-imx258";
    reg = <0x1A>;
    id = <0>;
    sensor_f_number = <2>;
    setfile = "default";
   };

   fimc-is-5e3@20 {
    compatible = "samsung,exynos5-fimc-is-cis-5e3";
    reg = <0x10>;
    id = <1>;
    sensor_f_number = <4>;
    setfile = "default";
   };
 };

 hsi2c_3: hsi2c@138C0000 {
  gpios = <&gpf0 2 0 &gpf0 3 0>;
  status = "okay";
  clock-frequency = <400000>;

  pinctrl-names = "default", "on_i2c";
  pinctrl-0 = <&hs_i2c3_bus>;
  pinctrl-1 = <&hs_i2c3_bus>;

  rear_eeprom@58 {
   compatible = "samsung,rear-eeprom-i2c";
   reg = <0x58>;
  };

  fimc-is-actuator@0C {
    compatible = "samsung,exynos5-fimc-is-actuator-dw9807";
    reg = <0x0C>;
    id = <0>;
  };
 };
# 1080 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xe_common.dtsi"
 fimc_is_sensor0: fimc_is_sensor0@14420000 {
  scenario = <0>;
  id = <0>;
  csi_ch = <0>;
  flite_ch = <0>;
  is_bns = <1>;
  status = "okay";
 };

 fimc_is_sensor1: fimc_is_sensor1@14420000 {
  scenario = <0>;
  id = <1>;
  csi_ch = <0>;
  flite_ch = <0>;
  is_bns = <1>;
  status = "okay";
 };

 exynos_rgt {
  compatible = "samsung,exynos-rgt";
 };

 but_zones: but_zones {
  #list-but-cells = <3>;
 };

 speedy@10510000 {
  status = "okay";

  audio_codec_cod9002x: cod9002x@03 {
   compatible = "codec,cod9002x";
   reg = <0x03>;
   i2c-speedy-address;
   vdd-supply = <&ldo13_reg>;
   pinctrl-names = "default";



   mic-bias1-voltage = <1>;
   mic-bias2-voltage = <1>;
   mic-bias-ldo-voltage = <3>;
   use-btn-adc-mode;
   io-channels = <&exynos_adc 2>;
   io-channel-names = "adc-jack";
   #io-channel-cells = <1>;
   io-channel-ranges;
   but-zones-list = <&but_zones 226 0 217>,
    <&but_zones 582 218 296>,
    <&but_zones 115 297 498>,
    <&but_zones 114 499 1000>;
   mic-adc-range = <1350>;
  };

  s2mpu06mfd@00 {
   compatible = "samsung,s2mpu06mfd";
   reg = <0x00>;
   pinctrl-names = "default";
   pinctrl-0 = <&if_irq>;
   s2mpu06,wakeup = "enabled";
   s2mpu06,irq-gpio = <&gpa0 5 0>;

   i2c-speedy-address;
   cache_data = <1>;


   wtsr_en = "enabled";
   smpl_en = "enabled";
   wtsr_timer_val = <3>;
   smpl_timer_val = <0>;
   check_jigon = <0>;

   init_time,sec = <0>;
   init_time,min = <0>;
   init_time,hour = <0>;
   init_time,mday = <1>;
   init_time,mon = <0>;
   init_time,year = <116>;
   init_time,wday = <5>;

   samsung,codec-interrupt = <&audio_codec_cod9002x>;
   s2mpu06-keys {
    button@1 {
     label = "pmic-keys: KEY_POWER";
     linux,code = <116>;
     wakeup = <1>;
    };
   };

   regulators {
    buck1_reg: BUCK1 {
     regulator-name = "BUCK1";
     regulator-min-microvolt = <500000>;
     regulator-max-microvolt = <1300000>;
     regulator-always-on;
     regulator-boot-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
     regulator-expected-consumer = <6>;
    };

    buck2_reg: BUCK2 {
     regulator-name = "BUCK2";
     regulator-min-microvolt = <800000>;
     regulator-max-microvolt = <2800000>;
     regulator-always-on;
     regulator-boot-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
    };

    buck3_reg: BUCK3 {
     regulator-name = "BUCK3";
     regulator-min-microvolt = <800000>;
     regulator-max-microvolt = <2800000>;
     regulator-always-on;
     regulator-boot-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
    };

    ldo1_reg: LDO1 {
     regulator-name = "vdd_ldo1";
     regulator-min-microvolt = <500000>;
     regulator-max-microvolt = <1300000>;
     regulator-always-on;
     regulator-boot-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <1>;
    };

    ldo2_reg: LDO2 {
     regulator-name = "vdd_ldo2";
     regulator-min-microvolt = <1500000>;
     regulator-max-microvolt = <2000000>;
     regulator-boot-on;
     regulator-always-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
    };

    ldo3_reg: LDO3 {
     regulator-name = "vdd_ldo3";
     regulator-min-microvolt = <800000>;
     regulator-max-microvolt = <1500000>;
     regulator-boot-on;
     regulator-always-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
    };

    ldo4_reg: LDO4 {
     regulator-name = "vqmmc";
     regulator-min-microvolt = <1700000>;
     regulator-max-microvolt = <3350000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo5_reg: LDO5 {
     regulator-name = "vdd_ldo5";
     regulator-min-microvolt = <1700000>;
     regulator-max-microvolt = <3350000>;
     regulator-boot-on;
     regulator-always-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
    };

    ldo6_reg: LDO6 {
     regulator-name = "vdd_ldo6";
     regulator-min-microvolt = <500000>;
     regulator-max-microvolt = <1300000>;
     regulator-boot-on;
     regulator-always-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
    };

    ldo7_reg: LDO7 {
     regulator-name = "vdd_ldo7";
     regulator-min-microvolt = <800000>;
     regulator-max-microvolt = <1300000>;
     regulator-boot-on;
     regulator-always-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <1>;
    };

    ldo8_reg: LDO8 {
     regulator-name = "vdd_ldo8";
     regulator-min-microvolt = <1800000>;
     regulator-max-microvolt = <3375000>;
     regulator-boot-on;
     regulator-always-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <1>;
    };

    ldo13_reg: LDO13 {
     regulator-name = "vdd_ldo13";
     regulator-min-microvolt = <800000>;
     regulator-max-microvolt = <2000000>;
     regulator-ramp-delay = <12000>;
     regulator-always-on;
     regulator-boot-on;
     regulator-initial-mode = <3>;
    };

    ldo14_reg: LDO14 {
     regulator-name = "vemmc";
     regulator-min-microvolt = <1800000>;
     regulator-max-microvolt = <3375000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo15_reg: LDO15 {
     regulator-name = "vqemmc";
     regulator-min-microvolt = <800000>;
     regulator-max-microvolt = <2000000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo16_reg: LDO16 {
     regulator-name = "vmmc";
     regulator-min-microvolt = <1800000>;
     regulator-max-microvolt = <3375000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo17_reg: LDO17 {
     regulator-name = "VDD18_CAM_SENSOR_IO";
     regulator-min-microvolt = <1800000>;
     regulator-max-microvolt = <1800000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo18_reg: LDO18 {
     regulator-name = "VDD28_CAM_AF";
     regulator-min-microvolt = <2800000>;
     regulator-max-microvolt = <2800000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo19_reg: LDO19 {
     regulator-name = "touchkey_3p0";
     regulator-min-microvolt = <3000000>;
     regulator-max-microvolt = <3000000>;
     regulator-boot-on;
    };

    ldo20_reg: LDO20 {
     regulator-name = "LCD_1P8";
     regulator-min-microvolt = <1800000>;
     regulator-max-microvolt = <1800000>;
     regulator-boot-on;
     regulator-initial-mode = <3>;
    };

    ldo21_reg: LDO21 {
     regulator-name = "VDD21_MOTOR_3P0";
     regulator-min-microvolt = <3000000>;
     regulator-max-microvolt = <3000000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo22_reg: LDO22 {
     regulator-name = "vdd_ldo22";
     regulator-min-microvolt = <1800000>;
     regulator-max-microvolt = <3375000>;
     regulator-always-on;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <3>;
    };

    ldo23_reg: LDO23 {
     regulator-name = "VDD23_CAM_CORE_1P2";
     regulator-min-microvolt = <1200000>;
     regulator-max-microvolt = <1200000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };

    ldo24_reg: LDO24 {
     regulator-name = "AVDD24_CAM_2P8";
     regulator-min-microvolt = <2800000>;
     regulator-max-microvolt = <2800000>;
     regulator-ramp-delay = <12000>;
     regulator-initial-mode = <0>;
    };
   };
  };

  fimc_is_flash@06 {
   compatible = "samsung,sensor-flash-i2c";
   reg = <0x06>;
   id = <0>;
   flash-gpio = <&gpa0 0 0>;
   flash_current = <1200>;
   preflash_current = <160>;
   movie_current = <160>;
   torch_current = <80>;
   factory_current = <160>;
   i2c-speedy-address;
  };
 };


 mif_pdata {
  reg = <0 0x10000 0x0>;

  pinctrl-names = "default";
  pinctrl-0 = <&cp_gpio_on5>;

  gpios = <&gpd1 2 0>,
   <&gpd1 3 0>,
   <&gpd1 4 0>,
   <&gpd1 5 0>;
 };

 exynos-pm {
  compatible = "samsung,exynos-pm";
  reg = <0x0 0x139F0000 0x1000>,
        <0x0 0x104E1200 0x100>;
  reg-names = "gpio_alive_base",
       "gicd_ispendrn_base";
  num-eint = <24>;
  num-gic = <16>;
  suspend_mode_idx = <7>;
  suspend_psci_idx = <131>;
  cp_call_mode_idx = <4>;
  cp_call_psci_idx = <132>;
 };

 acpm: acpm@11C88000 {
  compatible = "samsung,exynos-acpm";
  #address-cells = <2>;
  #size-cells = <1>;
  reg = <0x0 0x11C88000 0x1000>;

  log_base = <0x02047700>;
  time_len = <32>;
  log_buff_size = <16>;
  log_buff_len = <380>;
  debug_logging_level = <0>;
  logging_period = <500>;

  dump_base = <0x02046000>;
  dump_size = <0x3800>;

  plugins {
   framework {
    attach = <2>;
    id = <0>;
    acpm-ipc-channel = <&framework_ch>;
   };
  };
 };

 acpm_ipc: acpm_ipc@11C00000 {
  compatible = "samsung,exynos-acpm-ipc";
  #address-cells = <2>;
  #size-cells = <1>;

  interrupts = <0 22 0>;
  reg = <0x0 0x11C00000 0x1000>;

  channels {
   polling = <1>;
   max_buff_size = <0x300>;
   framework_ch: framework@0x02047400 {
    channel_id = <0>;
    rx_buff = <0x02047400>;
    tx_buff = <0x02047480>;
    buff_size = <12>;
    buff_len = <8>;
    direction_buff = <412>;
   };
  };
 };

 s1403x: s1403x@14880000 {
  pinctrl-names = "default", "idle";
  pinctrl-0 = <&i2s_pmic_bus
   &i2s_codec_clk>;
  pinctrl-1 = <&i2s_pmic_bus_idle>;
  bck-mcko-mode;
  status = "okay";
 };

 i2s_dummy: dummy-i2s {
  compatible = "samsung,dummy-i2s";
  status = "okay";
 };

 i2s0: i2s@148A0000 {
  status = "okay";
 };

 i2s1: i2s@148B0000 {
  status = "okay";
 };

 audio_cp_dummy: cp_dummy {
  compatible = "samsung,cp_dummy";
  status = "okay";
 };

 audio_fm_dummy: fm_dummy {
  compatible = "samsung,fm_dummy";
  status = "okay";
 };

 audio_bt_dummy: bt_dummy {
  compatible = "samsung,bt_dummy";
  status = "okay";
 };

 audio_codec_dummy: dummy-codec {
  compatible = "samsung,dummy-codec";
  status = "okay";
 };

 sound {
  compatible = "samsung,universal7570-cod9002x";
  samsung,audio-cpu = <&i2s0
   &i2s0
   &audio_cp_dummy
   &audio_bt_dummy
   &audio_fm_dummy
   &i2s1
   &audio_cp_dummy
   &eax
   &eax
   &eax
   &eax>;
  samsung,audio-codec = <&audio_codec_cod9002x
   &audio_codec_cod9002x
   &audio_codec_cod9002x
   &audio_codec_dummy
   &audio_codec_cod9002x
   &audio_codec_dummy
   &audio_codec_dummy
   &audio_codec_cod9002x
   &audio_codec_cod9002x
   &audio_codec_cod9002x
   &audio_codec_cod9002x>;

  samsung,auxdev = <&s1403x>;
  mic-bias-mode = <1 0 2 0>;
  status = "okay";
 };

 sec_thermistor@0 {
  compatible = "samsung,sec-ap-thermistor";
  status = "okay";

  adc_array = <285 296 306 317 327 338 350 361 373 384
    396 408 420 433 445 457 474 491 508 525
    541 563 584 605 626 648 668 690 711 732
    753 776 798 822 844 868 898 928 958 988
    1018 1051 1084 1117 1150 1183 1217 1251 1286 1320
    1354 1395 1435 1476 1516 1557 1603 1649 1696 1743
    1789 1831 1874 1917 1959 2001 2049 2097 2145 2194
    2242 2291 2340 2389 2437 2485 2531 2576 2622 2667
    2713 2755 2797 2838 2880 2922 2965 3007 3050 3092
    3135 3168 3201 3235 3268 3301 3330 3360 3389 3419
    3448 3470 3492 3514 3536 3558 3582 3607 3631 3656 3680>;
  temp_array = <900 890 880 870 860 850 840 830 820 810
        800 790 780 770 760 750 740 730 720 710
        700 690 680 670 660 650 640 630 620 610
        600 590 580 570 560 550 540 530 520 510
        500 490 480 470 460 450 440 430 420 410
        400 390 380 370 360 350 340 330 320 310
        300 290 280 270 260 250 240 230 220 210
        200 190 180 170 160 150 140 130 120 110
        100 90 80 70 60 50 40 30 20 10
        0 (-10) (-20) (-30) (-40) (-50) (-60) (-70) (-80) (-90)
        (-100) (-110) (-120) (-130) (-140) (-150) (-160) (-170) (-180) (-190) (-200)>;
  io-channels = <&exynos_adc 0>;
  io-channel-names = "adc-ap-temp";
  io-channel-ranges;
 };

 argos {
  compatible = "samsung,argos";
  #address-cells = <1>;
# 1589 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xe_common.dtsi"
  boot_device@1 {
   net_boost,label="IPC";
   net_boost,node="rmnet0 rmnet1 rmnet2 rmnet3 rmnet4 rmnet5 rmnet6 rmnet7 umts_dm0";
   net_boost,table_size = <4>;
   net_boost,table= < 1 0 0 0 0 0 1
        20 829000 0 416000 100000 0 1
        50 1040000 0 825000 100000 0 1
       100 1430000 0 825000 100000 0 1>;
  };

  boot_device@2 {
   net_boost,label="USB";
   net_boost,node="rndis0";
   net_boost,table_size = <1>;
   net_boost,table= < 1 0 0 0 0 0 1 >;
  };

  boot_device@3 {
   net_boost,label="P2P";
   net_boost,node="p2p-wlan0-0";
   net_boost,table_size = <3>;
   net_boost,table= <
    30 1274000 0 415000 0 0 0
    50 1378000 0 415000 0 0 0
    90 1378000 0 666000 0 1 1
    >;
  };
  boot_device@4 {
   net_boost,label="WIFI";
   net_boost,node="wlan0";
   net_boost,table_size = <3>;
   net_boost,table= <
    10 1040000 0 415000 0 0 0
    60 1378000 0 666000 0 1 1
    120 1378000 0 666000 0 1 1
    >;
   };
# 1636 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xe_common.dtsi"
 };

 sec_vib {
  compatible = "sec_vib";
  sec_vib_pdata {
   status = "okay";
   sec_vib,max_timeout = <10000>;
   sec_vib,ldo_type = <1>;
   sec_vib,ldo_en = <&gpa0 3 0>;
  };
 };

 input_booster {
  status = "okay";
  compatible = "input_booster";
  #address-cells = <1>;
  #size-cells = <0>;

  booster_key@1 {
   input_booster,label = "KEY";
   input_booster,type = <0>;

   input_booster,levels = <1>;



   input_booster,cpu_freqs = <1274000>;
   input_booster,hmp_boost = <0>;
   input_booster,kfc_freqs = <1274000>;
   input_booster,mif_freqs = <0>;
   input_booster,int_freqs = <0>;


   input_booster,head_times = <500>;
   input_booster,tail_times = <500>;
   input_booster,phase_times = <0>;
  };
  booster_key@2 {
   input_booster,label = "TOUCHKEY";
   input_booster,type = <1>;

   input_booster,levels = <1>;



   input_booster,cpu_freqs = <1274000>;
   input_booster,hmp_boost = <0>;
   input_booster,kfc_freqs = <1274000>;
   input_booster,mif_freqs = <0>;
   input_booster,int_freqs = <0>;


   input_booster,head_times = <0>;
   input_booster,tail_times = <300>;
   input_booster,phase_times = <0>;
  };
  booster_key@3 {
   input_booster,label = "TOUCH";
   input_booster,type = <2>;

   input_booster,levels = <1 2 3>;



   input_booster,cpu_freqs = <1274000 1274000 962000>;
   input_booster,hmp_boost = <0 0 0>;
   input_booster,kfc_freqs = <1274000 1274000 962000>;
   input_booster,mif_freqs = <0 0 0>;
   input_booster,int_freqs = <0 0 0>;


   input_booster,head_times = <200 200 0>;
   input_booster,tail_times = <0 0 300>;
   input_booster,phase_times = <0 0 0>;
  };
  booster_key@4 {
   input_booster,label = "MULTITOUCH";
   input_booster,type = <3>;

   input_booster,levels = <1 2>;



   input_booster,cpu_freqs = <1378000 1040000>;
   input_booster,hmp_boost = <0 0>;
   input_booster,kfc_freqs = <1378000 1040000>;
   input_booster,mif_freqs = <0 0>;
   input_booster,int_freqs = <0 0>;


   input_booster,head_times = <1000 0>;
   input_booster,tail_times = <0 500>;
   input_booster,phase_times = <0 0>;
  };
  booster_key@5 {
   input_booster,label = "KEYBOARD";
   input_booster,type = <4>;

   input_booster,levels = <1 2>;



   input_booster,cpu_freqs = <1274000 1274000>;
   input_booster,hmp_boost = <0 0>;
   input_booster,kfc_freqs = <1274000 1274000>;
   input_booster,mif_freqs = <0 0>;
   input_booster,int_freqs = <0 0>;


   input_booster,head_times = <200 200>;
   input_booster,tail_times = <0 0>;
   input_booster,phase_times = <0 0>;
  };
  booster_key@6 {
   input_booster,label = "MOUSE";
   input_booster,type = <5>;

   input_booster,levels = <1 2>;



   input_booster,cpu_freqs = <1274000 962000>;
   input_booster,hmp_boost = <0 0>;
   input_booster,kfc_freqs = <1274000 962000>;
   input_booster,mif_freqs = <0 0>;
   input_booster,int_freqs = <0 0>;


   input_booster,head_times = <200 0>;
   input_booster,tail_times = <0 300>;
   input_booster,phase_times = <0 0>;
  };
  booster_key@7 {
   input_booster,label = "MOUSE WHEEL";
   input_booster,type = <6>;

   input_booster,levels = <1 2>;



   input_booster,cpu_freqs = <1274000 0>;
   input_booster,hmp_boost = <0 0>;
   input_booster,kfc_freqs = <1274000 0>;
   input_booster,mif_freqs = <0 0>;
   input_booster,int_freqs = <0 0>;


   input_booster,head_times = <200 0>;
   input_booster,tail_times = <0 0>;
   input_booster,phase_times = <0 0>;
  };
  booster_key@8 {
   input_booster,label = "PEN & HOVER";
   input_booster,type = <7>;

   input_booster,levels = <1 2>;



   input_booster,cpu_freqs = <1274000 962000>;
   input_booster,hmp_boost = <0 0>;
   input_booster,kfc_freqs = <1274000 962000>;
   input_booster,mif_freqs = <0 0>;
   input_booster,int_freqs = <0 0>;


   input_booster,head_times = <200 0>;
   input_booster,tail_times = <0 300>;
   input_booster,phase_times = <0 0>;
  };
  booster_key@9 {
   input_booster,label = "GAMEPAD";
   input_booster,type = <8>;

   input_booster,levels = <1 2>;



   input_booster,cpu_freqs = <1378000 829000>;
   input_booster,hmp_boost = <0 0>;
   input_booster,kfc_freqs = <1378000 829000>;
   input_booster,mif_freqs = <0 0>;
   input_booster,int_freqs = <0 0>;


   input_booster,head_times = <200 0>;
   input_booster,tail_times = <0 300>;
   input_booster,phase_times = <0 0>;
  };

 };
};
# 15 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/modem-ss305ap-pdata.dtsi" 1
# 12 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/modem-ss305ap-pdata.dtsi"
/ {

 mif_pdata {
  compatible = "sec_modem,modem_pdata";
  status = "okay";
  interrupts = <0 18 0>, <0 479 0>;


  mif,name = "ss305ap";
  mif,modem_net = <0>;
  mif,modem_type = <10>;
  mif,use_handover = <0>;
  mif,ipc_version = <50>;
  mif,link_types = <0x200>;
  mif,link_name = "shmem";
  mif,link_attrs = <0x7C8>;
  mif,num_iodevs = <19>;


  mbx_ap2cp_msg = <0>;
  mbx_cp2ap_msg = <1>;
  mbx_ap2cp_united_status = <2>;
  mbx_cp2ap_united_status = <3>;

  mif,int_ap2cp_msg = <0>;
  mif,int_ap2cp_status = <2>;
  mif,int_ap2cp_active = <3>;

  mif,irq_cp2ap_msg = <0>;
  mif,irq_cp2ap_status = <2>;
  mif,irq_cp2ap_active = <3>;
  mif,irq_cp2ap_wake_lock = <8>;


  mbx_cp2ap_dvfsreq = <4>;
  mbx_cp2ap_dvfsreq_mif = <6>;

  mif,irq_cp2ap_perf_req_mif = <6>;


  mbx_ap2cp_cp_voltage_700 = <5>;
  mbx_ap2cp_cp_voltage_830 = <7>;


  sbi_evs_mode_mask = <0x1>;
  sbi_evs_mode_pos = <7>;
  sbi_lte_active_mask = <0x1>;
  sbi_lte_active_pos = <5>;
  sbi_cp_status_mask = <0xf>;
  sbi_cp_status_pos = <1>;
  sbi_pda_active_mask = <0x1>;
  sbi_pda_active_pos = <5>;
  sbi_ap_status_mask = <0xf>;
  sbi_ap_status_pos = <1>;

  sbi_ds_det_mask = <0x3>;
  sbi_ds_det_pos = <14>;
  sbi_sys_rev_mask = <0xff>;
  sbi_sys_rev_pos = <6>;

  sbi_cp_cpu_freq_asv_mask = <0x7>;
  sbi_cp_cpu_freq_asv_pos = <19>;

  iodevs {
   io_device_0 {
    iod,name = "umts_ipc0";
    iod,id = <235>;
    iod,format = <0>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "RIL";
   };
   io_device_1 {
    iod,name = "umts_ipc1";
    iod,id = <236>;
    iod,format = <0>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "RIL";
   };
   io_device_2 {
    iod,name = "umts_rfs0";
    iod,id = <245>;
    iod,format = <2>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "RFS";
   };
   io_device_3 {
    iod,name = "umts_csd";
    iod,id = <1>;
    iod,format = <1>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "CSVT";
   };
   io_device_4 {
    iod,name = "umts_router";
    iod,id = <25>;
    iod,format = <1>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "Data Router";
    iod,max_tx_size = <2048>;
   };
   io_device_5 {
    iod,name = "umts_dm0";
    iod,id = <28>;
    iod,format = <1>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "DIAG";
   };
   io_device_6 {
    iod,name = "rmnet0";
    iod,id = <10>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "NET";
   };
   io_device_7 {
    iod,name = "rmnet1";
    iod,id = <11>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "NET";
      };
   io_device_8 {
    iod,name = "rmnet2";
    iod,id = <12>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "NET";
   };
   io_device_9 {
    iod,name = "rmnet3";
    iod,id = <13>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "NET";
   };
   io_device_10 {
    iod,name = "rmnet4";
    iod,id = <14>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
   };
   io_device_11 {
    iod,name = "rmnet5";
    iod,id = <15>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
   };
   io_device_12 {
    iod,name = "rmnet6";
    iod,id = <16>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
   };
   io_device_13 {
    iod,name = "rmnet7";
    iod,id = <17>;
    iod,format = <1>;
    iod,io_type = <1>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
   };
   io_device_14 {
    iod,name = "multipdp";
    iod,id = <0>;
    iod,format = <3>;
    iod,io_type = <2>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "RIL";
   };
   io_device_15 {
    iod,name = "umts_boot0";
    iod,id = <215>;
    iod,format = <4>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x2>;
    iod,app = "CBD";
   };
   io_device_16 {
    iod,name = "umts_ramdump0";
    iod,id = <225>;
    iod,format = <5>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x202>;
    iod,app = "CBD";
   };
   io_device_17 {
    iod,name = "smd4";
    iod,id = <33>;
    iod,format = <1>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x802>;
    iod,option_region = "kor_skt";
   };
   io_device_18 {
    iod,name = "umts_ciq0";
    iod,id = <26>;
    iod,format = <1>;
    iod,io_type = <0>;
    iod,links = <0x200>;
    iod,attrs = <0x802>;
    iod,option_region = "usa_att";
   };
  };
 };

 shmem: shmem@90000000 {
  compatible = "samsung,exynos-shm_ipc";

  shmem,ipc_offset = <0x5800000>;
  shmem,ipc_size = <0x400000>;
 };
};
# 16 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_battery_swa_00.dtsi" 1
# 12 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_battery_swa_00.dtsi"
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_battery.dtsi" 1
# 12 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_battery.dtsi"
/ {
 s2mpu06-fuelgauge {
  status = "disable";
  compatible = "samsung,s2mpu06-fuelgauge";
  fuelgauge,fuel_alert_soc = <1>;
  fuelgauge,capacity_max = <1000>;
  fuelgauge,capacity_max_margin = <200>;
  fuelgauge,capacity_min = <0>;
  fuelgauge,capacity_calculation_type = <28>;
  fuelgauge,type_str = "SDI";
  fuelgauge,model_type = <1>;

  fuelgauge,cell_character = <


   0x77 0x0A 0x2F 0x0A 0xAC 0x09 0x4B 0x09 0x04 0x09
   0x73 0x08 0x21 0x08 0xD6 0x07 0x8D 0x07 0x3E 0x07
   0xE0 0x06 0xAA 0x06 0x82 0x06 0x63 0x06 0x4A 0x06
   0x33 0x06 0x0F 0x06 0xE8 0x05 0xAF 0x05 0x85 0x05
   0x22 0x05 0x35 0x02 0x69 0x08 0x00 0x08 0x97 0x07
   0x2E 0x07 0xC5 0x06 0x5C 0x06 0xF3 0x05 0x8B 0x05
   0x22 0x05 0xB9 0x04 0x50 0x04 0xE7 0x03 0x7E 0x03
   0x15 0x03 0xAC 0x02 0x43 0x02 0xDA 0x01 0x72 0x01
   0x09 0x01 0xA0 0x00 0x37 0x00 0xE0 0x0F 0xFE 0x29
   0xDC 0x29 0x8A 0x29 0x4D 0x29 0x28 0x1F 0x7F 0x1F
   0x21 0x21 0x14 0x21 0xF7 0x0F 0xE6 0xF7 0xC4 0x1D
   0xCA 0xD4 0xD3 0xD4 0x40 0x80 0x26 0x33 0x26 0x40
   0x26 0x5C 0x26 0x5C 0x26 0x5C 0xFF 0xFF 0x02 0x05
   0x14 0x0B 0x03 0x12 0x06 0x1C 0x0C 0x1C 0x10 0x1C
   0x1F 0x1F 0x35 0x35 0x3D 0x3D 0x3D 0x3D 0x3D 0x3D
   0x3D 0x3D 0x3E 0x3F 0x3F 0x3F 0x40 0x40 0x41 0x42
   0x44 0x43 0x66 0x9A

   0x1F 0x60 0x09 0x00 0x00



   0xF5 0x09 0x87 0x09 0x25 0x09 0xC4 0x08 0x83 0x08
   0xF0 0x07 0xC0 0x07 0x81 0x07 0x25 0x07 0xD8 0x06
   0xA8 0x06 0x83 0x06 0x65 0x06 0x4C 0x06 0x37 0x06
   0x18 0x06 0xF4 0x05 0xC5 0x05 0x8D 0x05 0x7E 0x05
   0x09 0x04 0x2B 0x02 0x00 0x08 0x9B 0x07 0x36 0x07
   0xD2 0x06 0x6D 0x06 0x08 0x06 0xA3 0x05 0x3F 0x05
   0xDA 0x04 0x75 0x04 0x10 0x04 0xAB 0x03 0x47 0x03
   0xE2 0x02 0x7D 0x02 0x18 0x02 0xB4 0x01 0x4F 0x01
   0xEA 0x00 0x85 0x00 0x21 0x00 0xF9 0x0F 0xFE 0x29
   0xDC 0x29 0x8A 0x29 0x4D 0x29 0x28 0x1F 0x7F 0x1F
   0x21 0x21 0x14 0x21 0xF7 0x0F 0xE6 0xF7 0xC4 0x1D
   0xCA 0xD4 0xD3 0xD4 0x40 0x80 0x26 0x33 0x26 0x40
   0x26 0x5C 0x26 0x5C 0x26 0x5C 0xFF 0xFF 0x02 0x05
   0x14 0x0B 0x03 0x12 0x06 0x1C 0x0C 0x1C 0x10 0x1C
   0x1F 0x1F 0x35 0x35 0x3D 0x3D 0x3D 0x3D 0x3D 0x3D
   0x3D 0x3D 0x3E 0x3F 0x3F 0x3F 0x40 0x40 0x41 0x42
   0x44 0x43 0x66 0x9A

   0x1F 0x60 0x09 0x00 0x00



   0x14 0x0A 0xCF 0x09 0x64 0x09 0x03 0x09 0xA9 0x08
   0x50 0x08 0xD8 0x07 0xB0 0x07 0x6A 0x07 0x07 0x07
   0xC8 0x06 0x9C 0x06 0x79 0x06 0x5D 0x06 0x46 0x06
   0x31 0x06 0x0D 0x06 0xEB 0x05 0xB8 0x05 0x89 0x05
   0x6B 0x05 0x1B 0x03 0x67 0x08 0x00 0x08 0x99 0x07
   0x32 0x07 0xCB 0x06 0x64 0x06 0xFE 0x05 0x96 0x05
   0x2F 0x05 0xC9 0x04 0x62 0x04 0xFB 0x03 0x94 0x03
   0x2D 0x03 0xC6 0x02 0x5F 0x02 0xF8 0x01 0x91 0x01
   0x2A 0x01 0xC4 0x00 0x5D 0x00 0xF6 0x0F 0xFE 0x29
   0xDC 0x29 0x8A 0x29 0x4D 0x29 0x28 0x1F 0x7F 0x1F
   0x21 0x21 0x14 0x21 0xF7 0x0F 0xE6 0xF7 0xC4 0x1D
   0xCA 0xD4 0xD3 0xD4 0x40 0x80 0x26 0x33 0x26 0x40
   0x26 0x5C 0x26 0x5C 0x26 0x5C 0xFF 0xFF 0x02 0x05
   0x14 0x0B 0x03 0x12 0x06 0x1C 0x0C 0x1C 0x10 0x1C
   0x1F 0x1F 0x35 0x35 0x3D 0x3D 0x3D 0x3D 0x3D 0x3D
   0x3D 0x3D 0x3E 0x3F 0x3F 0x3F 0x40 0x40 0x41 0x42
   0x44 0x43 0x66 0x9A

   0x1F 0x60 0x09 0x00 0x00



   0xA7 0x09 0x41 0x09 0xE3 0x08 0x9A 0x08 0x1F 0x08
   0xCC 0x07 0xA2 0x07 0x5B 0x07 0xFB 0x06 0xC2 0x06
   0x99 0x06 0x78 0x06 0x5D 0x06 0x47 0x06 0x31 0x06
   0x0F 0x06 0xEF 0x05 0xBF 0x05 0x8C 0x05 0x7C 0x05
   0xFE 0x03 0x96 0x02 0x00 0x08 0x9B 0x07 0x35 0x07
   0xD0 0x06 0x6A 0x06 0x05 0x06 0x9F 0x05 0x3A 0x05
   0xD4 0x04 0x6F 0x04 0x0A 0x04 0xA4 0x03 0x3F 0x03
   0xD9 0x02 0x74 0x02 0x0E 0x02 0xA9 0x01 0x44 0x01
   0xDE 0x00 0x79 0x00 0x13 0x00 0xF3 0x0F 0xFE 0x29
   0xDC 0x29 0x8A 0x29 0x4D 0x29 0x28 0x1F 0x7F 0x1F
   0x21 0x21 0x14 0x21 0xF7 0x0F 0xE6 0xF7 0xC4 0x1D
   0xCA 0xD4 0xD3 0xD4 0x40 0x80 0x26 0x33 0x26 0x40
   0x26 0x5C 0x26 0x5C 0x26 0x5C 0xFF 0xFF 0x02 0x05
   0x14 0x0B 0x03 0x12 0x06 0x1C 0x0C 0x1C 0x10 0x1C
   0x1F 0x1F 0x35 0x35 0x3D 0x3D 0x3D 0x3D 0x3D 0x3D
   0x3D 0x3D 0x3E 0x3F 0x3F 0x3F 0x40 0x40 0x41 0x42
   0x44 0x43 0x66 0x9A

   0x1F 0x60 0x09 0x00 0x00



   0x85 0x09 0x45 0x09 0xE1 0x08 0x9C 0x08 0x2A 0x08
   0xD0 0x07 0xAC 0x07 0x6B 0x07 0x0D 0x07 0xCF 0x06
   0xA4 0x06 0x82 0x06 0x66 0x06 0x50 0x06 0x39 0x06
   0x20 0x06 0xFE 0x05 0xDD 0x05 0xA9 0x05 0x87 0x05
   0x59 0x05 0xFA 0x02 0x67 0x08 0x00 0x08 0x99 0x07
   0x32 0x07 0xCA 0x06 0x63 0x06 0xFC 0x05 0x94 0x05
   0x2D 0x05 0xC6 0x04 0x5F 0x04 0xF7 0x03 0x90 0x03
   0x29 0x03 0xC2 0x02 0x5A 0x02 0xF3 0x01 0x8C 0x01
   0x25 0x01 0xBD 0x00 0x56 0x00 0xEF 0x0F 0xFE 0x29
   0xDC 0x29 0x8A 0x29 0x4D 0x29 0x28 0x1F 0x7F 0x1F
   0x21 0x21 0x14 0x21 0xF7 0x0F 0xE6 0xF7 0xC4 0x1D
   0xCA 0xD4 0xD3 0xD4 0x40 0x80 0x26 0x33 0x26 0x40
   0x26 0x5C 0x26 0x5C 0x26 0x5C 0xFF 0xFF 0x02 0x05
   0x14 0x0B 0x03 0x12 0x06 0x1C 0x0C 0x1C 0x10 0x1C
   0x1F 0x1F 0x35 0x35 0x3D 0x3D 0x3D 0x3D 0x3D 0x3D
   0x3D 0x3D 0x3E 0x3F 0x3F 0x3F 0x40 0x40 0x41 0x42
   0x44 0x43 0x66 0x9A

   0x1F 0x60 0x09 0x00 0xEC
   >;



  fuelgauge,raw_100_vbat = <4273 4245 4226 4207 4159>;
 };

 battery {
  status = "okay";

  pinctrl-names = "default";

  compatible = "samsung,sec-battery";
  battery,vendor = "SDI SDI";
  battery,charger_name = "s2mpu06-charger";
  battery,fuelgauge_name = "s2mpu06-fuelgauge";
  battery,technology = <2>;

  battery,chip_vendor = "LSI";

  battery,battery_type = <&gpd1 5 0x1>;

  battery,temp_adc_type = <1>;

  battery,polling_time = <10 30 30 30 3600>;

  battery,temp_table_adc = <300 354 412 490 565 661 795 890 960 1072 1130 1200 1330 1570 1780 2010
        2240 2495 2726 2925 3126 3242 3324 3469 3591 3689>;

  battery,temp_table_data = <900 850 800 750 700 650 600 550 500 470 450 430 400 350 300 250
        200 150 100 50 0 (-30) (-50) (-100) (-150) (-200)>;

  battery,input_current_limit = <1300 460 460 1300 480 900 1000 480 1000 0 820 820 820 1300 1300 0 0 400 700 1000 300 1000 1300 0 1675 1675 1000 1675 80 1800 1675 1400 1000 1000 820 820>;
  battery,fast_charging_current = <1200 0 0 1200 800 1200 1000 800 1200 0 1200 1200 1200 1200 1200 0 0 400 700 1200 300 1000 1200 0 2550 2550 1000 2550 80 1800 1000 1400 0 1000 1200 1200>;
  battery,full_check_current_1st = <240 0 0 240 240 240 240 240 240 0 240 240 240 240 240 0 0 240 240 240 240 240 240 0 240 240 240 240 0 240 240 240 0 240 240 240>;
  battery,full_check_current_2nd = <120 0 0 120 120 120 120 120 120 0 120 120 120 120 120 0 0 120 120 120 120 120 120 0 120 120 120 120 0 120 120 120 0 120 120 120>;

  battery,wireless_cc_cv = <86>;
  battery,inbat_voltage = <1>;

  battery,inbat_voltage_table_adc = <3120 3101 3061 3038 3001 2956 2920 2887 2856 2814
      2793 2754 2720 2677 2641 2613 2572 2531 2502 2467 2436>;
  battery,inbat_voltage_table_data = <438 435 430 425 420 415 410 405 400 395
      390 385 380 375 370 365 360 355 350 345 340>;

  battery,adc_check_count = <5>;

  battery,cable_check_type = <4>;
  battery,cable_source_type = <1>;
  battery,polling_type = <1>;
  battery,monitor_initial_count = <0>;

  battery,battery_check_type = <5>;
  battery,check_count = <0>;

  battery,ovp_uvlo_check_type = <3>;

  battery,check_adc_max = <1440>;
  battery,check_adc_min = <0>;

  battery,thermal_source = <2>;

  battery,temp_check_type = <2>;
  battery,temp_check_count = <1>;
  battery,temp_highlimit_threshold_normal = <800>;
  battery,temp_highlimit_recovery_normal = <750>;
  battery,temp_high_threshold_normal = <500>;
  battery,temp_high_recovery_normal = <450>;
  battery,temp_low_threshold_normal = <0>;
  battery,temp_low_recovery_normal = <50>;
  battery,temp_highlimit_threshold_lpm = <800>;
  battery,temp_highlimit_recovery_lpm = <750>;
  battery,temp_high_threshold_lpm = <500>;
  battery,temp_high_recovery_lpm = <450>;
  battery,temp_low_threshold_lpm = <0>;
  battery,temp_low_recovery_lpm = <50>;

  battery,full_check_type = <7>;
  battery,full_check_type_2nd = <7>;
  battery,full_check_count = <1>;
  battery,chg_gpio_full_check = <0>;
  battery,chg_polarity_full_check = <1>;

  battery,chg_high_temp_1st = <530>;
  battery,chg_high_temp_2nd = <530>;
  battery,chg_high_temp_recovery = <525>;
  battery,chg_charging_limit_current = <1500>;
  battery,chg_charging_limit_current_2nd = <1500>;
  battery,chg_skip_check_capacity = <10>;
  battery,chg_skip_check_time = <600>;

  battery,wpc_high_temp = <420>;
  battery,wpc_high_temp_recovery = <410>;
  battery,wpc_charging_limit_current = <450>;




  battery,full_condition_type = <15>;
  battery,full_condition_soc = <93>;
  battery,full_condition_vcell = <4230>;
  battery,full_condition_vcell2 = <4230>;

  battery,recharge_check_count = <2>;
  battery,recharge_condition_type = <4>;
  battery,recharge_condition_soc = <98>;
  battery,recharge_condition_vcell = <4200>;
  battery,recharge_condition_vcell2 = <4200>;

  battery,standard_curr = <1046>;
  battery,recharging_expired_time = <5400>;
  battery,expired_time = <15000>;

  battery,charging_total_time = <21600>;
  battery,recharging_total_time = <5400>;
  battery,charging_reset_time = <0>;

  battery,chg_float_voltage = <4400>;
  battery,chg_float_voltage2 = <4350>;

  battery,self_discharging_temp_block = <600>;
  battery,self_discharging_volt_block = <4250>;
  battery,self_discharging_temp_recov = <550>;
  battery,self_discharging_temp_pollingtime = <400>;

  battery,swelling_high_temp_block = <410>;
  battery,swelling_high_temp_recov = <390>;

  battery,swelling_low_temp_2step_mode = <1>;
  battery,swelling_low_temp_block_1st = <150>;
  battery,swelling_low_temp_recov_1st = <200>;
  battery,swelling_low_temp_block_2nd = <50>;
  battery,swelling_low_temp_recov_2nd = <100>;

  battery,swelling_high_temp_current = <1000>;
  battery,swelling_low_temp_current = <720>;
  battery,swelling_low_temp_topoff = <150>;
  battery,swelling_high_temp_topoff = <150>;

  battery,swelling_drop_float_voltage = <4100>;
  battery,swelling_high_rechg_voltage = <3950>;
  battery,swelling_low_rechg_voltage = <3950>;
  battery,swelling_block_time = <600>;

  io-channels = <&exynos_adc 1>;
  io-channel-names = "adc-temp";
  #io-channel-cells = <1>;
  io-channel-ranges;


  battery,age_data = <0 4300 4200 4200 92
   200 4280 4180 4180 91
   250 4260 4160 4160 89
   300 4240 4140 4140 87
   1000 4190 4090 4090 83
   >;

  battery,data_ver = <0x2>;
 };

 s2mpu06-charger {
  status = "disable";
  compatible = "samsung,s2mpu06-charger";
  battery,is_1MHz_switching = <1>;
  battery,chg_gpio_en = <0>;
  battery,chg_polarity_en = <0>;
  battery,chg_gpio_status = <0>;
  battery,chg_polarity_status = <0>;
 };
};
# 12 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_battery_swa_00.dtsi" 2
# 17 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_gpio_01.dtsi" 1
# 10 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_gpio_01.dtsi"
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos_gpio_config_macros.dtsi" 1
# 11 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_gpio_01.dtsi" 2


&pinctrl_0 {
 pinctrl-names = "default";
 pinctrl-0 = <&initial0>;
 initial0: initial-state {
  gpq0-0 { samsung,pins = "gpq0-0"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };

  gpa0-3 { samsung,pins = "gpa0-3"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };
  gpa0-6 { samsung,pins = "gpa0-6"; samsung,pin-function = <0>; samsung,pin-pud = <0>; samsung,pin-drv = <0x0>; };
 };





};


&pinctrl_1 {
 pinctrl-names = "default","sleep";
 pinctrl-0 = <&initial1>;
 pinctrl-1 = <&sleep1>;
 initial1: initial-state {
  gpz1-1 { samsung,pins = "gpz1-1"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };
  gpz1-5 { samsung,pins = "gpz1-5"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };
 };
 sleep1: sleep-state {
  gpz1-0 { samsung,pins = "gpz1-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpz1-1 { samsung,pins = "gpz1-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpz1-2 { samsung,pins = "gpz1-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpz1-3 { samsung,pins = "gpz1-3"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpz1-5 { samsung,pins = "gpz1-5"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpz1-6 { samsung,pins = "gpz1-6"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
 };
};


&pinctrl_2 {
 pinctrl-names = "sleep";
 pinctrl-0 = <&sleep2>;
 sleep2: sleep-state {
  gpc7-0 { samsung,pins = "gpc7-0"; samsung,pin-con-pdn = <0>; samsung,pin-pud-pdn = <0>; };
  gpc7-1 { samsung,pins = "gpc7-1"; samsung,pin-con-pdn = <0>; samsung,pin-pud-pdn = <0>; };
  gpc7-2 { samsung,pins = "gpc7-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpc7-3 { samsung,pins = "gpc7-3"; samsung,pin-con-pdn = <0>; samsung,pin-pud-pdn = <0>; };
  gpc7-4 { samsung,pins = "gpc7-4"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
 };
};


&pinctrl_3 {
 pinctrl-names = "sleep";
 pinctrl-0 = <&sleep3>;
 sleep3: sleep-state {
  gpr0-1 { samsung,pins = "gpr0-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
 };
};





&pinctrl_5 {
 pinctrl-names = "sleep";
 pinctrl-0 = <&sleep5>;
 sleep5: sleep-state {
  gpc2-0 { samsung,pins = "gpc2-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
  gpc2-1 { samsung,pins = "gpc2-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
  gpc2-2 { samsung,pins = "gpc2-2"; samsung,pin-con-pdn = <3>; samsung,pin-pud-pdn = <1>; };
  gpc2-3 { samsung,pins = "gpc2-3"; samsung,pin-con-pdn = <3>; samsung,pin-pud-pdn = <0>; };
 };
};


&pinctrl_6 {
 pinctrl-names = "default","sleep";
 pinctrl-0 = <&initial6>;
 pinctrl-1 = <&sleep6>;
 initial6: initial-state {
  gpc0-1 { samsung,pins = "gpc0-1"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };
  gpc0-2 { samsung,pins = "gpc0-2"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };

  gpd1-2 { samsung,pins = "gpd1-2"; samsung,pin-function = <0>; samsung,pin-pud = <0>; samsung,pin-drv = <0x0>; };
  gpd1-3 { samsung,pins = "gpd1-3"; samsung,pin-function = <0>; samsung,pin-pud = <0>; samsung,pin-drv = <0x0>; };
  gpd1-4 { samsung,pins = "gpd1-4"; samsung,pin-function = <0>; samsung,pin-pud = <0>; samsung,pin-drv = <0x0>; };
  gpd1-5 { samsung,pins = "gpd1-5"; samsung,pin-function = <0>; samsung,pin-pud = <0>; samsung,pin-drv = <0x0>; };

  gpe0-2 { samsung,pins = "gpe0-2"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };

  gpf3-1 { samsung,pins = "gpf3-1"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };

  gpf1-0 { samsung,pins = "gpf1-0"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };
  gpf1-1 { samsung,pins = "gpf1-1"; samsung,pin-function = <0>; samsung,pin-pud = <1>; samsung,pin-drv = <0x0>; };

 };
 sleep6: sleep-state {
  gpc0-1 { samsung,pins = "gpc0-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpc0-2 { samsung,pins = "gpc0-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };

  gpc1-2 { samsung,pins = "gpc1-2"; samsung,pin-con-pdn = <3>; samsung,pin-pud-pdn = <3>; };
  gpc1-3 { samsung,pins = "gpc1-3"; samsung,pin-con-pdn = <3>; samsung,pin-pud-pdn = <3>; };

  gpc4-0 { samsung,pins = "gpc4-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpc4-1 { samsung,pins = "gpc4-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpc4-2 { samsung,pins = "gpc4-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
  gpc4-3 { samsung,pins = "gpc4-3"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };

  gpd1-0 { samsung,pins = "gpd1-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpd1-1 { samsung,pins = "gpd1-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpd1-2 { samsung,pins = "gpd1-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
  gpd1-3 { samsung,pins = "gpd1-3"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
  gpd1-4 { samsung,pins = "gpd1-4"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
  gpd1-5 { samsung,pins = "gpd1-5"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <0>; };
  gpd1-6 { samsung,pins = "gpd1-6"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };

  gpe0-0 { samsung,pins = "gpe0-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpe0-1 { samsung,pins = "gpe0-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpe0-2 { samsung,pins = "gpe0-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };

  gpf0-0 { samsung,pins = "gpf0-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpf0-1 { samsung,pins = "gpf0-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpf0-2 { samsung,pins = "gpf0-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpf0-3 { samsung,pins = "gpf0-3"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };

  gpf1-0 { samsung,pins = "gpf1-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpf1-1 { samsung,pins = "gpf1-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };

  gpf3-0 { samsung,pins = "gpf3-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpf3-1 { samsung,pins = "gpf3-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpf3-2 { samsung,pins = "gpf3-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpf3-3 { samsung,pins = "gpf3-3"; samsung,pin-con-pdn = <3>; samsung,pin-pud-pdn = <0>; };
 };
};


&pinctrl_7 {
 pinctrl-names = "sleep";
 pinctrl-0= <&sleep7>;
 sleep7: sleep-state {
  gpc3-0 { samsung,pins = "gpc3-0"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpc3-1 { samsung,pins = "gpc3-1"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
  gpc3-2 { samsung,pins = "gpc3-2"; samsung,pin-con-pdn = <2>; samsung,pin-pud-pdn = <1>; };
 };
};
# 18 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts" 2
# 1 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_fingerprint-sensor_00.dtsi" 1
# 14 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_fingerprint-sensor_00.dtsi"
/ {
 pinctrl@139F0000 {
  btp_irq: btp-irq {
   samsung,pins = "gpa1-3";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <3>;
  };
  btp_check: btp-check {
   samsung,pins = "gpa2-5";
   samsung,pin-function = <0>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <3>;
  };
 };
 pinctrl@139B0000 {
  btp_reset: btp-reset {
   samsung,pins = "gpf3-3";
   samsung,pin-function = <1>;
   samsung,pin-pud = <0>;
   samsung,pin-drv = <1>;
  };
 };

 pinctrl@139C0000 {
  btp_ldo: btp-ldo {
   samsung,pins = "gpc2-3";
   samsung,pin-function = <1>;
   samsung,pin-pud = <1>;
   samsung,pin-drv = <0>;
  };
 };

 spi_0: spi@100C0000 {
  status = "okay";
  secure-mode;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "idle";
  pinctrl-0 = <&spi0_bus>;
  pinctrl-1 = <&spi0_bus_inactive>;

  etspi-spi@0 {
   compatible = "etspi,et510";
   reg = <0>;
   spi-max-frequency = <16000000>;
   pinctrl-names = "default";
   pinctrl-0 = <&btp_irq &btp_reset &btp_ldo &btp_check>;

   gpio-controller;
   #gpio-cells = <2>;

   etspi-sleepPin = <&gpf3 3 0x00>;
   etspi-drdyPin = <&gpa1 3 0x00>;
   etspi-ldoPin = <&gpc2 3 0x00>;
   controller-data {
    samsung,spi-feedback-delay = <0>;
    samsung,spi-chip-select-mode = <0>;
   };
  };
 };
};
# 19 "/media/sarr/SARR-DRIVER/sdk/xc/arch/arm64/boot/dts/exynos7570-on5xelte_swa_open_01.dts" 2

/ {
 model = "Samsung ON5XELTE SWA rev01 board based on Exynos7570";
        model_info-chip = <7570>;
        model_info-platform = "android";
        model_info-subtype = "samsung";
        model_info-hw_rev = <1>;
        model_info-hw_rev_end = <1>;
 compatible = "samsung,exynos7570", "samsung,exynos4210";

 sec_vib {
  compatible = "sec_vib";
  sec_vib_pdata {
   status = "okay";
   sec_vib,max_timeout = <10000>;
   sec_vib,ldo_type = <0>;
   sec_vib,regulator = "VDD21_MOTOR_3P0";
  };
 };

 fm_gpio: fm@14840000 {
  vol_3db_on = <1>;
 };


 usim_det {
  pinctrl-names = "default";
  pinctrl-0 = <&sim0_gpio_on5 &sim1_gpio_on5>;

  mif,num_of_usim_det = <2>;
  mif,usim-det0-gpio = <&gpa2 4 0>;
  mif,usim-det1-gpio = <&gpa1 4 0>;

 };
};
