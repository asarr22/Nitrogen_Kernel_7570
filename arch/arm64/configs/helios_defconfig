## arch/arm64/configs/helios_defconfig
```kconfig
#
#
# Nitrogen defconfig
#
CONFIG_BOEFFLA_WL_BLOCKER=y
CONFIG_POWERSUSPEND=y
# CONFIG_POWERSUSPEND_DEBUG is not set
CONFIG_DYNAMIC_FSYNC=y 
```
